# Repository vrs42/Eagle (continued)

## EAGLE design projects/32k-Omnibus/legenda.brd (continued)

Schematic: Lafferty1ab.sch, sheet 4

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15, A16, A17, A18, A19, A20, A21, A22, A23, A24, A25, A26, A27, A28, A29, A30, A31, A32, A33, A34, A35, A36, A37, A38, A39, A40, A41, A42, A43, A44, A45, A46, A47, A48, A49, A50, A51, A52, A53, A54, A55, A56, A57, A58, A59, A60, A61, A62, A63, A64, A65, A66, A67, A68, A69, A70, A71, A72, A73, A74, A75, A76, A77, A78, A79, A80, A81, A82, A83, A84, A85, A86, A87, A88, A89, A90, A91, A92, A93, A94, A95, A96, A97, A98, A99, A100, A101, A102, A103, A104, A105, A106, A107, A108, A109, A110, A111, A112, A113, A114, A115, A116, A117, A118, A119, A120, A121, A122, A123, A124, A125, A126, A127, A128, A129, A130, A131, A132, A133, A134, A135, A136, A137, A138, A139, A140, A141, A142, A143, A144, A145, A146, A147, A148, A149, A150, A151, A152, A153, A154, A155, A156, A157, A158, A159, A160, A161, A162, A163, A164, A165, A166, A167, A168, A169, A170, A171, A172, A173, A174, A175, A176, A177, A178, A179, A180, A181, A182, A183, A184, A185, A186, A187, A188, A189, A190, A191, A192, A193, A194, A195, A196, A197, A198, A199, A200, A201, A202, A203, A204, A205, A206, A207, A208, A209, A210, A211, A212, A213, A214, A215, A216, A217, A218, A219, A220, A221, A222, A223, A224, A225, A226, A227, A228, A229, A230, A231, A232, A233, A234, A235, A236, A237, A238, A239, A240, A241, A242, A243, A244, A245, A246, A247, A248, A249, A250, A251, A252, A253, A254, A255, A256, A257, A258, A259, A260, A261, A262, A263, A264, A265, A266, A267, A268, A269, A270, A271, A272, A273, A274, A275, A276, A277, A278, A279, A280, A281, A282, A283, A284, A285, A286, A287, A288, A289, A290, A291, A292, A293, A294, A295, A296, A297, A298, A299, A300, A301, A302, A303, A304, A305, A306, A307, A308, A309, A310, A311, A312, A313, A314, A315, A316, A317, A318, A319, A320, A321, A322, A323, A324, A325, A326, A327, A328, A329, A330, A331, A332, A333, A334, A335, A336, A337, A338, A339, A340, A341, A342, A343, A344, A345, A346, A347, A348, A349, A350, A351, A352, A353, A354, A355, A356, A357, A358, A359, A360, A361, A362, A363, A364, A365, A366, A367, A368, A369, A370, A371, A372, A373, A374, A375, A376, A377, A378, A379, A380, A381, A382, A383, A384, A385, A386, A387, A388, A389, A390, A391, A392, A393, A394, A395, A396, A397, A398, A399, A400, A401, A402, A403, A404, A405, A406, A407, A408, A409, A410, A411, A412, A413, A414, A415, A416, A417, A418, A419, A420, A421, A422, A423, A424, A425, A426, A427, A428, A429, A430, A431, A432, A433, A434, A435, A436, A437, A438, A439, A440, A441, A442, A443, A444, A445, A446, A447, A448: JP1E; JP1
GND1, GND2, GND3, GND4, GND5, GND6, GND7, GND8, GND9, GND10, GND11, GND12, GND13, GND14, GND15, GND16, GND17, GND18, GND19, GND20, GND21, GND22, GND23, GND24, GND25, GND26, GND27, GND28, GND29, GND30, GND31, GND32, GND33, GND34, GND35, GND36, GND37, GND38, GND39, GND40, GND41, GND42, GND43, GND44: JP1E; JP1
IC9, IC10, IC11, IC12, IC13, IC14, IC15, IC16, IC17, IC18, IC19, IC20, IC21, IC22, IC23, IC24, IC25, IC26, IC27, IC28, IC29, IC30, IC31, IC32, IC33, IC34, IC35, IC36: DIL16
VCC1, VCC2, VCC3, VCC4, VCC5, VCC6, VCC7, VCC8, VCC9, VCC10, VCC11, VCC12, VCC13, VCC14, VCC15, VCC16, VCC17, VCC18, VCC19, VCC20, VCC21, VCC22, VCC23, VCC24, VCC25, VCC26, VCC27, VCC28, VCC29, VCC30, VCC31, VCC32, VCC33, VCC34, VCC35, VCC36, VCC37, VCC38, VCC39, VCC40, VCC41, VCC42, VCC43, VCC44: JP1E; JP1

Connections:
unnamed: A16.1, A16.2, IC9.16
unnamed: A14.1, A14.2, IC9.14
unnamed: A9.1, A9.2, IC9.9
unnamed: A15.1, A15.2, IC9.15
unnamed: A10.1, A10.2, IC9.10
unnamed: A13.1, A13.2, IC9.13
unnamed: A32.1, A32.2, IC10.16
unnamed: A12.1, A12.2, IC9.12
unnamed: A11.1, A11.2, IC9.11
unnamed: A1.1, A1.2, IC9.1
unnamed: A8.1, A8.2, IC9.8
unnamed: A2.1, A2.2, IC9.2
unnamed: A7.1, A7.2, IC9.7
unnamed: A3.1, A3.2, IC9.3
unnamed: A4.1, A4.2, IC9.4
unnamed: A5.1, A5.2, IC9.5
unnamed: A6.1, A6.2, IC9.6
unnamed: A25.1, A25.2, IC10.9
unnamed: A31.1, A31.2, IC10.15
unnamed: A26.1, A26.2, IC10.10
unnamed: A30.1, A30.2, IC10.14
unnamed: A29.1, A29.2, IC10.13
unnamed: A28.1, A28.2, IC10.12
unnamed: A27.1, A27.2, IC10.11
unnamed: A17.1, A17.2, IC10.1
unnamed: A24.1, A24.2, IC10.8
unnamed: A18.1, A18.2, IC10.2
unnamed: A23.1, A23.2, IC10.7
unnamed: A19.1, A19.2, IC10.3
unnamed: A20.1, A20.2, IC10.4
unnamed: A21.1, A21.2, IC10.5
unnamed: A22.1, A22.2, IC10.6
unnamed: A48.1, A48.2, IC11.16
unnamed: A41.1, A41.2, IC11.9
unnamed: A47.1, A47.2, IC11.15
unnamed: A42.1, A42.2, IC11.10
unnamed: A46.1, A46.2, IC11.14
unnamed: A45.1, A45.2, IC11.13
unnamed: A44.1, A44.2, IC11.12
unnamed: A43.1, A43.2, IC11.11
unnamed: A33.1, A33.2, IC11.1
unnamed: A40.1, A40.2, IC11.8
unnamed: A34.1, A34.2, IC11.2
unnamed: A39.1, A39.2, IC11.7
unnamed: A35.1, A35.2, IC11.3
unnamed: A36.1, A36.2, IC11.4
unnamed: A37.1, A37.2, IC11.5
unnamed: A38.1, A38.2, IC11.6
unnamed: A64.1, A64.2, IC12.16
unnamed: A57.1, A57.2, IC12.9
unnamed: A63.1, A63.2, IC12.15
unnamed: A58.1, A58.2, IC12.10
unnamed: A62.1, A62.2, IC12.14
unnamed: A61.1, A61.2, IC12.13
unnamed: A60.1, A60.2, IC12.12
unnamed: A59.1, A59.2, IC12.11
unnamed: A49.1, A49.2, IC12.1
unnamed: A56.1, A56.2, IC12.8
unnamed: A50.1, A50.2, IC12.2
unnamed: A55.1, A55.2, IC12.7
unnamed: A51.1, A51.2, IC12.3
unnamed: A52.1, A52.2, IC12.4
unnamed: A53.1, A53.2, IC12.5
unnamed: A54.1, A54.2, IC12.6
unnamed: A80.1, A80.2, IC13.16
unnamed: A73.1, A73.2, IC13.9
unnamed: A79.1, A79.2, IC13.15
unnamed: A74.1, A74.2, IC13.10
unnamed: A78.1, A78.2, IC13.14
unnamed: A77.1, A77.2, IC13.13
unnamed: A76.1, A76.2, IC13.12
unnamed: A75.1, A75.2, IC13.11
unnamed: A65.1, A65.2, IC13.1
unnamed: A72.1, A72.2, IC13.8
unnamed: A66.1, A66.2, IC13.2
unnamed: A71.1, A71.2, IC13.7
unnamed: A67.1, A67.2, IC13.3
unnamed: A68.1, A68.2, IC13.4
unnamed: A69.1, A69.2, IC13.5
unnamed: A70.1, A70.2, IC13.6
unnamed: A96.1, A96.2, IC14.16
unnamed: A89.1, A89.2, IC14.9
unnamed: A95.1, A95.2, IC14.15
unnamed: A90.1, A90.2, IC14.10
unnamed: A94.1, A94.2, IC14.14
unnamed: A93.1, A93.2, IC14.13
unnamed: A92.1, A92.2, IC14.12
unnamed: A91.1, A91.2, IC14.11
unnamed: A81.1, A81.2, IC14.1
unnamed: A88.1, A88.2, IC14.8
unnamed: A82.1, A82.2, IC14.2
unnamed: A87.1, A87.2, IC14.7
unnamed: A83.1, A83.2, IC14.3
unnamed: A84.1, A84.2, IC14.4
unnamed: A85.1, A85.2, IC14.5
unnamed: A86.1, A86.2, IC14.6
unnamed: A112.1, A112.2, IC15.16
unnamed: A105.1, A105.2, IC15.9
unnamed: A111.1, A111.2, IC15.15
unnamed: A106.1, A106.2, IC15.10
unnamed: A110.1, A110.2, IC15.14
unnamed: A109.1, A109.2, IC15.13
unnamed: A108.1, A108.2, IC15.12
unnamed: A107.1, A107.2, IC15.11
unnamed: A97.1, A97.2, IC15.1
unnamed: A104.1, A104.2, IC15.8
unnamed: A98.1, A98.2, IC15.2
unnamed: A103.1, A103.2, IC15.7
unnamed: A99.1, A99.2, IC15.3
unnamed: A100.1, A100.2, IC15.4
unnamed: A101.1, A101.2, IC15.5
unnamed: A102.1, A102.2, IC15.6
unnamed: A128.1, A128.2, IC16.16
unnamed: A121.1, A121.2, IC16.9
unnamed: A127.1, A127.2, IC16.15
unnamed: A122.1, A122.2, IC16.10
unnamed: A126.1, A126.2, IC16.14
unnamed: A125.1, A125.2, IC16.13
unnamed: A124.1, A124.2, IC16.12
unnamed: A123.1, A123.2, IC16.11
unnamed: A113.1, A113.2, IC16.1
unnamed: A120.1, A120.2, IC16.8
unnamed: A114.1, A114.2, IC16.2
unnamed: A119.1, A119.2, IC16.7
unnamed: A115.1, A115.2, IC16.3
unnamed: A116.1, A116.2, IC16.4
unnamed: A117.1, A117.2, IC16.5
unnamed: A118.1, A118.2, IC16.6
unnamed: A144.1, A144.2, IC17.16
unnamed: A137.1, A137.2, IC17.9
unnamed: A143.1, A143.2, IC17.15
unnamed: A138.1, A138.2, IC17.10
unnamed: A142.1, A142.2, IC17.14
unnamed: A141.1, A141.2, IC17.13
unnamed: A140.1, A140.2, IC17.12
unnamed: A139.1, A139.2, IC17.11
unnamed: A129.1, A129.2, IC17.1
unnamed: A136.1, A136.2, IC17.8
unnamed: A130.1, A130.2, IC17.2
unnamed: A135.1, A135.2, IC17.7
unnamed: A131.1, A131.2, IC17.3
unnamed: A132.1, A132.2, IC17.4
unnamed: A133.1, A133.2, IC17.5
unnamed: A134.1, A134.2, IC17.6
unnamed: A160.1, A160.2, IC18.16
unnamed: A153.1, A153.2, IC18.9
unnamed: A159.1, A159.2, IC18.15
unnamed: A154.1, A154.2, IC18.10
unnamed: A158.1, A158.2, IC18.14
unnamed: A157.1, A157.2, IC18.13
unnamed: A156.1, A156.2, IC18.12
unnamed: A155.1, A155.2, IC18.11
unnamed: A145.1, A145.2, IC18.1
unnamed: A152.1, A152.2, IC18.8
unnamed: A146.1, A146.2, IC18.2
unnamed: A151.1, A151.2, IC18.7
unnamed: A147.1, A147.2, IC18.3
unnamed: A148.1, A148.2, IC18.4
unnamed: A149.1, A149.2, IC18.5
unnamed: A150.1, A150.2, IC18.6
unnamed: A176.1, A176.2, IC19.16
unnamed: A169.1, A169.2, IC19.9
unnamed: A175.1, A175.2, IC19.15
unnamed: A170.1, A170.2, IC19.10
unnamed: A174.1, A174.2, IC19.14
unnamed: A173.1, A173.2, IC19.13
unnamed: A172.1, A172.2, IC19.12
unnamed: A171.1, A171.2, IC19.11
unnamed: A161.1, A161.2, IC19.1
unnamed: A168.1, A168.2, IC19.8
unnamed: A162.1, A162.2, IC19.2
unnamed: A167.1, A167.2, IC19.7
unnamed: A163.1, A163.2, IC19.3
unnamed: A164.1, A164.2, IC19.4
unnamed: A165.1, A165.2, IC19.5
unnamed: A166.1, A166.2, IC19.6
unnamed: A192.1, A192.2, IC20.16
unnamed: A185.1, A185.2, IC20.9
unnamed: A191.1, A191.2, IC20.15
unnamed: A186.1, A186.2, IC20.10
unnamed: A190.1, A190.2, IC20.14
unnamed: A189.1, A189.2, IC20.13
unnamed: A188.1, A188.2, IC20.12
unnamed: A187.1, A187.2, IC20.11
unnamed: A177.1, A177.2, IC20.1
unnamed: A184.1, A184.2, IC20.8
unnamed: A178.1, A178.2, IC20.2
unnamed: A183.1, A183.2, IC20.7
unnamed: A179.1, A179.2, IC20.3
unnamed: A180.1, A180.2, IC20.4
unnamed: A181.1, A181.2, IC20.5
unnamed: A182.1, A182.2, IC20.6
unnamed: A304.1, A304.2, IC27.16
unnamed: A297.1, A297.2, IC27.9
unnamed: A208.1, A208.2, IC21.16
unnamed: A201.1, A201.2, IC21.9
unnamed: A207.1, A207.2, IC21.15
unnamed: A202.1, A202.2, IC21.10
unnamed: A206.1, A206.2, IC21.14
unnamed: A205.1, A205.2, IC21.13
unnamed: A204.1, A204.2, IC21.12
unnamed: A203.1, A203.2, IC21.11
unnamed: A193.1, A193.2, IC21.1
unnamed: A200.1, A200.2, IC21.8
unnamed: A194.1, A194.2, IC21.2
unnamed: A199.1, A199.2, IC21.7
unnamed: A195.1, A195.2, IC21.3
unnamed: A196.1, A196.2, IC21.4
unnamed: A197.1, A197.2, IC21.5
unnamed: A198.1, A198.2, IC21.6
unnamed: A224.1, A224.2, IC22.16
unnamed: A217.1, A217.2, IC22.9
unnamed: A223.1, A223.2, IC22.15
unnamed: A218.1, A218.2, IC22.10
unnamed: A222.1, A222.2, IC22.14
unnamed: A221.1, A221.2, IC22.13
unnamed: A220.1, A220.2, IC22.12
unnamed: A219.1, A219.2, IC22.11
unnamed: A209.1, A209.2, IC22.1
unnamed: A216.1, A216.2, IC22.8
unnamed: A210.1, A210.2, IC22.2
unnamed: A215.1, A215.2, IC22.7
unnamed: A211.1, A211.2, IC22.3
unnamed: A212.1, A212.2, IC22.4
unnamed: A213.1, A213.2, IC22.5
unnamed: A214.1, A214.2, IC22.6
unnamed: A240.1, A240.2, IC23.16
unnamed: A233.1, A233.2, IC23.9
unnamed: A239.1, A239.2, IC23.15
unnamed: A234.1, A234.2, IC23.10
unnamed: A238.1, A238.2, IC23.14
unnamed: A237.1, A237.2, IC23.13
unnamed: A236.1, A236.2, IC23.12
unnamed: A235.1, A235.2, IC23.11
unnamed: A225.1, A225.2, IC23.1
unnamed: A232.1, A232.2, IC23.8
unnamed: A226.1, A226.2, IC23.2
unnamed: A231.1, A231.2, IC23.7
unnamed: A227.1, A227.2, IC23.3
unnamed: A228.1, A228.2, IC23.4
unnamed: A229.1, A229.2, IC23.5
unnamed: A230.1, A230.2, IC23.6
unnamed: A256.1, A256.2, IC24.16
unnamed: A249.1, A249.2, IC24.9
unnamed: A255.1, A255.2, IC24.15
unnamed: A250.1, A250.2, IC24.10
unnamed: A254.1, A254.2, IC24.14
unnamed: A253.1, A253.2, IC24.13
unnamed: A252.1, A252.2, IC24.12
unnamed: A251.1, A251.2, IC24.11
unnamed: A241.1, A241.2, IC24.1
unnamed: A248.1, A248.2, IC24.8
unnamed: A242.1, A242.2, IC24.2
unnamed: A247.1, A247.2, IC24.7
unnamed: A243.1, A243.2, IC24.3
unnamed: A244.1, A244.2, IC24.4
unnamed: A245.1, A245.2, IC24.5
unnamed: A246.1, A246.2, IC24.6
unnamed: A272.1, A272.2, IC25.16
unnamed: A265.1, A265.2, IC25.9
unnamed: A271.1, A271.2, IC25.15
unnamed: A266.1, A266.2, IC25.10
unnamed: A270.1, A270.2, IC25.14
unnamed: A269.1, A269.2, IC25.13
unnamed: A268.1, A268.2, IC25.12
unnamed: A267.1, A267.2, IC25.11
unnamed: A257.1, A257.2, IC25.1
unnamed: A264.1, A264.2, IC25.8
unnamed: A258.1, A258.2, IC25.2
unnamed: A263.1, A263.2, IC25.7
unnamed: A259.1, A259.2, IC25.3
unnamed: A260.1, A260.2, IC25.4
unnamed: A261.1, A261.2, IC25.5
unnamed: A262.1, A262.2, IC25.6
unnamed: A288.1, A288.2, IC26.16
unnamed: A281.1, A281.2, IC26.9
unnamed: A287.1, A287.2, IC26.15
unnamed: A282.1, A282.2, IC26.10
unnamed: A286.1, A286.2, IC26.14
unnamed: A285.1, A285.2, IC26.13
unnamed: A284.1, A284.2, IC26.12
unnamed: A283.1, A283.2, IC26.11
unnamed: A273.1, A273.2, IC26.1
unnamed: A280.1, A280.2, IC26.8
unnamed: A274.1, A274.2, IC26.2
unnamed: A279.1, A279.2, IC26.7
unnamed: A275.1, A275.2, IC26.3
unnamed: A276.1, A276.2, IC26.4
unnamed: A277.1, A277.2, IC26.5
unnamed: A278.1, A278.2, IC26.6
unnamed: A303.1, A303.2, IC27.15
unnamed: A298.1, A298.2, IC27.10
unnamed: A302.1, A302.2, IC27.14
unnamed: A301.1, A301.2, IC27.13
unnamed: A300.1, A300.2, IC27.12
unnamed: A299.1, A299.2, IC27.11
unnamed: A289.1, A289.2, IC27.1
unnamed: A296.1, A296.2, IC27.8
unnamed: A290.1, A290.2, IC27.2
unnamed: A295.1, A295.2, IC27.7
unnamed: A291.1, A291.2, IC27.3
unnamed: A292.1, A292.2, IC27.4
unnamed: A293.1, A293.2, IC27.5
unnamed: A294.1, A294.2, IC27.6
unnamed: A320.1, A320.2, IC28.16
unnamed: A313.1, A313.2, IC28.9
unnamed: A319.1, A319.2, IC28.15
unnamed: A314.1, A314.2, IC28.10
unnamed: A318.1, A318.2, IC28.14
unnamed: A317.1, A317.2, IC28.13
unnamed: A316.1, A316.2, IC28.12
unnamed: A315.1, A315.2, IC28.11
unnamed: A305.1, A305.2, IC28.1
unnamed: A312.1, A312.2, IC28.8
unnamed: A306.1, A306.2, IC28.2
unnamed: A311.1, A311.2, IC28.7
unnamed: A307.1, A307.2, IC28.3
unnamed: A308.1, A308.2, IC28.4
unnamed: A309.1, A309.2, IC28.5
unnamed: A310.1, A310.2, IC28.6
unnamed: A336.1, A336.2, IC29.16
unnamed: A329.1, A329.2, IC29.9
unnamed: A335.1, A335.2, IC29.15
unnamed: A330.1, A330.2, IC29.10
unnamed: A334.1, A334.2, IC29.14
unnamed: A333.1, A333.2, IC29.13
unnamed: A332.1, A332.2, IC29.12
unnamed: A331.1, A331.2, IC29.11
unnamed: A321.1, A321.2, IC29.1
unnamed: A328.1, A328.2, IC29.8
unnamed: A322.1, A322.2, IC29.2
unnamed: A327.1, A327.2, IC29.7
unnamed: A323.1, A323.2, IC29.3
unnamed: A324.1, A324.2, IC29.4
unnamed: A325.1, A325.2, IC29.5
unnamed: A326.1, A326.2, IC29.6
unnamed: A352.1, A352.2, IC30.16
unnamed: A345.1, A345.2, IC30.9
unnamed: A351.1, A351.2, IC30.15
unnamed: A346.1, A346.2, IC30.10
unnamed: A350.1, A350.2, IC30.14
unnamed: A349.1, A349.2, IC30.13
unnamed: A348.1, A348.2, IC30.12
unnamed: A347.1, A347.2, IC30.11
unnamed: A337.1, A337.2, IC30.1
unnamed: A344.1, A344.2, IC30.8
unnamed: A338.1, A338.2, IC30.2
unnamed: A343.1, A343.2, IC30.7
unnamed: A339.1, A339.2, IC30.3
unnamed: A340.1, A340.2, IC30.4
unnamed: A341.1, A341.2, IC30.5
unnamed: A342.1, A342.2, IC30.6
unnamed: A368.1, A368.2, IC31.16
unnamed: A361.1, A361.2, IC31.9
unnamed: A367.1, A367.2, IC31.15
unnamed: A362.1, A362.2, IC31.10
unnamed: A366.1, A366.2, IC31.14
unnamed: A365.1, A365.2, IC31.13
unnamed: A364.1, A364.2, IC31.12
unnamed: A363.1, A363.2, IC31.11
unnamed: A353.1, A353.2, IC31.1
unnamed: A360.1, A360.2, IC31.8
unnamed: A354.1, A354.2, IC31.2
unnamed: A359.1, A359.2, IC31.7
unnamed: A355.1, A355.2, IC31.3
unnamed: A356.1, A356.2, IC31.4
unnamed: A357.1, A357.2, IC31.5
unnamed: A358.1, A358.2, IC31.6
unnamed: A384.1, A384.2, IC32.16
unnamed: A377.1, A377.2, IC32.9
unnamed: A383.1, A383.2, IC32.15
unnamed: A378.1, A378.2, IC32.10
unnamed: A382.1, A382.2, IC32.14
unnamed: A381.1, A381.2, IC32.13
unnamed: A380.1, A380.2, IC32.12
unnamed: A379.1, A379.2, IC32.11
unnamed: A369.1, A369.2, IC32.1
unnamed: A376.1, A376.2, IC32.8
unnamed: A370.1, A370.2, IC32.2
unnamed: A375.1, A375.2, IC32.7
unnamed: A371.1, A371.2, IC32.3
unnamed: A372.1, A372.2, IC32.4
unnamed: A373.1, A373.2, IC32.5
unnamed: A374.1, A374.2, IC32.6
unnamed: A400.1, A400.2, IC33.16
unnamed: A393.1, A393.2, IC33.9
unnamed: A399.1, A399.2, IC33.15
unnamed: A394.1, A394.2, IC33.10
unnamed: A398.1, A398.2, IC33.14
unnamed: A397.1, A397.2, IC33.13
unnamed: A396.1, A396.2, IC33.12
unnamed: A395.1, A395.2, IC33.11
unnamed: A385.1, A385.2, IC33.1
unnamed: A392.1, A392.2, IC33.8
unnamed: A386.1, A386.2, IC33.2
unnamed: A391.1, A391.2, IC33.7
unnamed: A387.1, A387.2, IC33.3
unnamed: A388.1, A388.2, IC33.4
unnamed: A389.1, A389.2, IC33.5
unnamed: A390.1, A390.2, IC33.6
unnamed: A416.1, A416.2, IC34.16
unnamed: A409.1, A409.2, IC34.9
unnamed: A415.1, A415.2, IC34.15
unnamed: A410.1, A410.2, IC34.10
unnamed: A414.1, A414.2, IC34.14
unnamed: A413.1, A413.2, IC34.13
unnamed: A412.1, A412.2, IC34.12
unnamed: A411.1, A411.2, IC34.11
unnamed: A401.1, A401.2, IC34.1
unnamed: A408.1, A408.2, IC34.8
unnamed: A402.1, A402.2, IC34.2
unnamed: A407.1, A407.2, IC34.7
unnamed: A403.1, A403.2, IC34.3
unnamed: A404.1, A404.2, IC34.4
unnamed: A405.1, A405.2, IC34.5
unnamed: A406.1, A406.2, IC34.6
unnamed: A432.1, A432.2, IC35.16
unnamed: A425.1, A425.2, IC35.9
unnamed: A431.1, A431.2, IC35.15
unnamed: A426.1, A426.2, IC35.10
unnamed: A430.1, A430.2, IC35.14
unnamed: A429.1, A429.2, IC35.13
unnamed: A428.1, A428.2, IC35.12
unnamed: A427.1, A427.2, IC35.11
unnamed: A417.1, A417.2, IC35.1
unnamed: A424.1, A424.2, IC35.8
unnamed: A418.1, A418.2, IC35.2
unnamed: A423.1, A423.2, IC35.7
unnamed: A419.1, A419.2, IC35.3
unnamed: A420.1, A420.2, IC35.4
unnamed: A421.1, A421.2, IC35.5
unnamed: A422.1, A422.2, IC35.6
unnamed: A448.1, A448.2, IC36.16
unnamed: A441.1, A441.2, IC36.9
unnamed: A447.1, A447.2, IC36.15
unnamed: A442.1, A442.2, IC36.10
unnamed: A446.1, A446.2, IC36.14
unnamed: A445.1, A445.2, IC36.13
unnamed: A444.1, A444.2, IC36.12
unnamed: A443.1, A443.2, IC36.11
unnamed: A433.1, A433.2, IC36.1
unnamed: A440.1, A440.2, IC36.8
unnamed: A434.1, A434.2, IC36.2
unnamed: A439.1, A439.2, IC36.7
unnamed: A435.1, A435.2, IC36.3
unnamed: A436.1, A436.2, IC36.4
unnamed: A437.1, A437.2, IC36.5
unnamed: A438.1, A438.2, IC36.6

Notes on the sheet:
16 Pin Socket Areas
Douglas Electronics

Schematic: Lafferty1ab.sch, sheet 5

Parts:
SV1, SV2, SV7, SV8, SV13, SV14, SV15, SV16, SV17, SV18, SV19, SV20, SV21, SV22, SV23, SV24, SV25, SV26, SV27, SV28, SV29, SV30, SV31, SV32, SV33, SV34, SV35, SV36, SV37, SV38, SV39, SV40, SV41, SV42, SV43, SV44, SV45, SV46, SV47, SV48, SV49, SV50, SV51, SV52, SV53, SV54, SV55, SV56, SV57, SV58, SV59, SV60, SV61, SV62, SV63, SV64, SV65, SV66, SV67, SV68, SV69, SV70, SV71, SV72, SV73, SV74, SV75, SV76, SV77, SV78, SV79, SV80, SV81, SV82, SV83, SV84, SV85, SV86, SV87, SV88, SV89, SV90, SV91, SV92, SV93, SV94, SV95, SV96, SV97, SV98, SV99, SV100, SV101, SV102, SV103, SV104, SV105, SV106, SV107, SV108, SV109, SV110, SV111, SV112, SV113, SV114, SV115, SV116, SV117, SV118, SV119, SV120, SV121, SV122, SV123, SV124, SV126, SV128, SV130, SV132, SV133, SV134, SV135, SV136, SV137, SV138, SV139, SV140, SV141, SV142, SV143, SV144, SV145, SV146, SV147, SV148, SV149, SV150, SV151, SV152, SV153, SV154, SV155, SV156, SV157, SV158, SV159, SV160, SV161, SV162, SV163, SV164, SV165, SV166, SV167, SV168, SV169, SV170, SV171, SV172, SV173, SV174: MA05-2
SV3, SV4, SV5, SV6, SV125, SV131, SV175, SV176: MA20-1
SV9, SV10, SV127, SV177, SV178: MA08-1
SV11, SV12, SV129, SV179, SV180: MA10-1

Connections:
unnamed: SV1.1, SV1.3, SV1.5, SV1.7, SV1.9
unnamed: SV1.2, SV1.4, SV1.6, SV1.8, SV1.10
unnamed: SV7.1, SV7.3, SV7.5, SV7.7, SV7.9
unnamed: SV2.1, SV2.3, SV2.5, SV2.7, SV2.9
unnamed: SV2.2, SV2.4, SV2.6, SV2.8, SV2.10
unnamed: SV7.2, SV7.4, SV7.6, SV7.8, SV7.10
unnamed: SV8.1, SV8.3, SV8.5, SV8.7, SV8.9
unnamed: SV8.2, SV8.4, SV8.6, SV8.8, SV8.10
unnamed: SV13.1, SV13.3, SV13.5, SV13.7, SV13.9
unnamed: SV13.2, SV13.4, SV13.6, SV13.8, SV13.10
unnamed: SV14.1, SV14.3, SV14.5, SV14.7, SV14.9
unnamed: SV14.2, SV14.4, SV14.6, SV14.8, SV14.10
unnamed: SV15.1, SV15.3, SV15.5, SV15.7, SV15.9
unnamed: SV15.2, SV15.4, SV15.6, SV15.8, SV15.10
unnamed: SV16.1, SV16.3, SV16.5, SV16.7, SV16.9
unnamed: SV16.2, SV16.4, SV16.6, SV16.8, SV16.10
unnamed: SV17.1, SV17.3, SV17.5, SV17.7, SV17.9
unnamed: SV17.2, SV17.4, SV17.6, SV17.8, SV17.10
unnamed: SV18.1, SV18.3, SV18.5, SV18.7, SV18.9
unnamed: SV18.2, SV18.4, SV18.6, SV18.8, SV18.10
unnamed: SV19.1, SV19.3, SV19.5, SV19.7, SV19.9
unnamed: SV19.2, SV19.4, SV19.6, SV19.8, SV19.10
unnamed: SV20.1, SV20.3, SV20.5, SV20.7, SV20.9
unnamed: SV20.2, SV20.4, SV20.6, SV20.8, SV20.10
unnamed: SV21.1, SV21.3, SV21.5, SV21.7, SV21.9
unnamed: SV21.2, SV21.4, SV21.6, SV21.8, SV21.10
unnamed: SV22.1, SV22.3, SV22.5, SV22.7, SV22.9
unnamed: SV22.2, SV22.4, SV22.6, SV22.8, SV22.10
unnamed: SV23.1, SV23.3, SV23.5, SV23.7, SV23.9
unnamed: SV23.2, SV23.4, SV23.6, SV23.8, SV23.10
unnamed: SV24.1, SV24.3, SV24.5, SV24.7, SV24.9
unnamed: SV24.2, SV24.4, SV24.6, SV24.8, SV24.10
unnamed: SV25.1, SV25.3, SV25.5, SV25.7, SV25.9
unnamed: SV25.2, SV25.4, SV25.6, SV25.8, SV25.10
unnamed: SV26.1, SV26.3, SV26.5, SV26.7, SV26.9
unnamed: SV26.2, SV26.4, SV26.6, SV26.8, SV26.10
unnamed: SV27.1, SV27.3, SV27.5, SV27.7, SV27.9
unnamed: SV27.2, SV27.4, SV27.6, SV27.8, SV27.10
unnamed: SV28.1, SV28.3, SV28.5, SV28.7, SV28.9
unnamed: SV28.2, SV28.4, SV28.6, SV28.8, SV28.10
unnamed: SV29.1, SV29.3, SV29.5, SV29.7, SV29.9
unnamed: SV29.2, SV29.4, SV29.6, SV29.8, SV29.10
unnamed: SV30.1, SV30.3, SV30.5, SV30.7, SV30.9
unnamed: SV30.2, SV30.4, SV30.6, SV30.8, SV30.10
unnamed: SV31.1, SV31.3, SV31.5, SV31.7, SV31.9
unnamed: SV31.2, SV31.4, SV31.6, SV31.8, SV31.10
unnamed: SV32.1, SV32.3, SV32.5, SV32.7, SV32.9
unnamed: SV32.2, SV32.4, SV32.6, SV32.8, SV32.10
unnamed: SV33.1, SV33.3, SV33.5, SV33.7, SV33.9
unnamed: SV33.2, SV33.4, SV33.6, SV33.8, SV33.10
unnamed: SV34.1, SV34.3, SV34.5, SV34.7, SV34.9
unnamed: SV34.2, SV34.4, SV34.6, SV34.8, SV34.10
unnamed: SV35.1, SV35.3, SV35.5, SV35.7, SV35.9
unnamed: SV35.2, SV35.4, SV35.6, SV35.8, SV35.10
unnamed: SV36.1, SV36.3, SV36.5, SV36.7, SV36.9
unnamed: SV36.2, SV36.4, SV36.6, SV36.8, SV36.10
unnamed: SV37.1, SV37.3, SV37.5, SV37.7, SV37.9
unnamed: SV37.2, SV37.4, SV37.6, SV37.8, SV37.10
unnamed: SV38.1, SV38.3, SV38.5, SV38.7, SV38.9
unnamed: SV38.2, SV38.4, SV38.6, SV38.8, SV38.10
unnamed: SV39.1, SV39.3, SV39.5, SV39.7, SV39.9
unnamed: SV39.2, SV39.4, SV39.6, SV39.8, SV39.10
unnamed: SV40.1, SV40.3, SV40.5, SV40.7, SV40.9
unnamed: SV40.2, SV40.4, SV40.6, SV40.8, SV40.10
unnamed: SV41.1, SV41.3, SV41.5, SV41.7, SV41.9
unnamed: SV41.2, SV41.4, SV41.6, SV41.8, SV41.10
unnamed: SV42.1, SV42.3, SV42.5, SV42.7, SV42.9
unnamed: SV42.2, SV42.4, SV42.6, SV42.8, SV42.10
unnamed: SV43.1, SV43.3, SV43.5, SV43.7, SV43.9
unnamed: SV43.2, SV43.4, SV43.6, SV43.8, SV43.10
unnamed: SV44.1, SV44.3, SV44.5, SV44.7, SV44.9
unnamed: SV44.2, SV44.4, SV44.6, SV44.8, SV44.10
unnamed: SV45.1, SV45.3, SV45.5, SV45.7, SV45.9
unnamed: SV45.2, SV45.4, SV45.6, SV45.8, SV45.10
unnamed: SV46.1, SV46.3, SV46.5, SV46.7, SV46.9
unnamed: SV46.2, SV46.4, SV46.6, SV46.8, SV46.10
unnamed: SV47.1, SV47.3, SV47.5, SV47.7, SV47.9
unnamed: SV47.2, SV47.4, SV47.6, SV47.8, SV47.10
unnamed: SV48.1, SV48.3, SV48.5, SV48.7, SV48.9
unnamed: SV48.2, SV48.4, SV48.6, SV48.8, SV48.10
unnamed: SV49.1, SV49.3, SV49.5, SV49.7, SV49.9
unnamed: SV49.2, SV49.4, SV49.6, SV49.8, SV49.10
unnamed: SV50.1, SV50.3, SV50.5, SV50.7, SV50.9
unnamed: SV50.2, SV50.4, SV50.6, SV50.8, SV50.10
unnamed: SV51.1, SV51.3, SV51.5, SV51.7, SV51.9
unnamed: SV51.2, SV51.4, SV51.6, SV51.8, SV51.10
unnamed: SV52.1, SV52.3, SV52.5, SV52.7, SV52.9
unnamed: SV52.2, SV52.4, SV52.6, SV52.8, SV52.10
unnamed: SV53.1, SV53.3, SV53.5, SV53.7, SV53.9
unnamed: SV53.2, SV53.4, SV53.6, SV53.8, SV53.10
unnamed: SV54.1, SV54.3, SV54.5, SV54.7, SV54.9
unnamed: SV54.2, SV54.4, SV54.6, SV54.8, SV54.10
unnamed: SV55.1, SV55.3, SV55.5, SV55.7, SV55.9
unnamed: SV55.2, SV55.4, SV55.6, SV55.8, SV55.10
unnamed: SV56.1, SV56.3, SV56.5, SV56.7, SV56.9
unnamed: SV56.2, SV56.4, SV56.6, SV56.8, SV56.10
unnamed: SV57.1, SV57.3, SV57.5, SV57.7, SV57.9
unnamed: SV57.2, SV57.4, SV57.6, SV57.8, SV57.10
unnamed: SV58.1, SV58.3, SV58.5, SV58.7, SV58.9
unnamed: SV58.2, SV58.4, SV58.6, SV58.8, SV58.10
unnamed: SV59.1, SV59.3, SV59.5, SV59.7, SV59.9
unnamed: SV59.2, SV59.4, SV59.6, SV59.8, SV59.10
unnamed: SV60.1, SV60.3, SV60.5, SV60.7, SV60.9
unnamed: SV60.2, SV60.4, SV60.6, SV60.8, SV60.10
unnamed: SV61.1, SV61.3, SV61.5, SV61.7, SV61.9
unnamed: SV61.2, SV61.4, SV61.6, SV61.8, SV61.10
unnamed: SV62.1, SV62.3, SV62.5, SV62.7, SV62.9
unnamed: SV62.2, SV62.4, SV62.6, SV62.8, SV62.10
unnamed: SV63.1, SV63.3, SV63.5, SV63.7, SV63.9
unnamed: SV63.2, SV63.4, SV63.6, SV63.8, SV63.10
unnamed: SV64.1, SV64.3, SV64.5, SV64.7, SV64.9
unnamed: SV64.2, SV64.4, SV64.6, SV64.8, SV64.10
unnamed: SV65.1, SV65.3, SV65.5, SV65.7, SV65.9
unnamed: SV65.2, SV65.4, SV65.6, SV65.8, SV65.10
unnamed: SV66.1, SV66.3, SV66.5, SV66.7, SV66.9
unnamed: SV66.2, SV66.4, SV66.6, SV66.8, SV66.10
unnamed: SV67.1, SV67.3, SV67.5, SV67.7, SV67.9
unnamed: SV67.2, SV67.4, SV67.6, SV67.8, SV67.10
unnamed: SV68.1, SV68.3, SV68.5, SV68.7, SV68.9
unnamed: SV68.2, SV68.4, SV68.6, SV68.8, SV68.10
unnamed: SV69.1, SV69.3, SV69.5, SV69.7, SV69.9
unnamed: SV69.2, SV69.4, SV69.6, SV69.8, SV69.10
unnamed: SV70.1, SV70.3, SV70.5, SV70.7, SV70.9
unnamed: SV70.2, SV70.4, SV70.6, SV70.8, SV70.10
unnamed: SV71.1, SV71.3, SV71.5, SV71.7, SV71.9
unnamed: SV71.2, SV71.4, SV71.6, SV71.8, SV71.10
unnamed: SV72.1, SV72.3, SV72.5, SV72.7, SV72.9
unnamed: SV72.2, SV72.4, SV72.6, SV72.8, SV72.10
unnamed: SV73.1, SV73.3, SV73.5, SV73.7, SV73.9
unnamed: SV73.2, SV73.4, SV73.6, SV73.8, SV73.10
unnamed: SV74.1, SV74.3, SV74.5, SV74.7, SV74.9
unnamed: SV74.2, SV74.4, SV74.6, SV74.8, SV74.10
unnamed: SV75.1, SV75.3, SV75.5, SV75.7, SV75.9
unnamed: SV75.2, SV75.4, SV75.6, SV75.8, SV75.10
unnamed: SV76.1, SV76.3, SV76.5, SV76.7, SV76.9
unnamed: SV76.2, SV76.4, SV76.6, SV76.8, SV76.10
unnamed: SV77.1, SV77.3, SV77.5, SV77.7, SV77.9
unnamed: SV77.2, SV77.4, SV77.6, SV77.8, SV77.10
unnamed: SV78.1, SV78.3, SV78.5, SV78.7, SV78.9
unnamed: SV78.2, SV78.4, SV78.6, SV78.8, SV78.10
unnamed: SV79.1, SV79.3, SV79.5, SV79.7, SV79.9
unnamed: SV79.2, SV79.4, SV79.6, SV79.8, SV79.10
unnamed: SV80.1, SV80.3, SV80.5, SV80.7, SV80.9
unnamed: SV80.2, SV80.4, SV80.6, SV80.8, SV80.10
unnamed: SV81.1, SV81.3, SV81.5, SV81.7, SV81.9
unnamed: SV81.2, SV81.4, SV81.6, SV81.8, SV81.10
unnamed: SV82.1, SV82.3, SV82.5, SV82.7, SV82.9
unnamed: SV82.2, SV82.4, SV82.6, SV82.8, SV82.10
unnamed: SV83.1, SV83.3, SV83.5, SV83.7, SV83.9
unnamed: SV83.2, SV83.4, SV83.6, SV83.8, SV83.10
unnamed: SV84.1, SV84.3, SV84.5, SV84.7, SV84.9
unnamed: SV84.2, SV84.4, SV84.6, SV84.8, SV84.10
unnamed: SV85.1, SV85.3, SV85.5, SV85.7, SV85.9
unnamed: SV85.2, SV85.4, SV85.6, SV85.8, SV85.10
unnamed: SV86.1, SV86.3, SV86.5, SV86.7, SV86.9
unnamed: SV86.2, SV86.4, SV86.6, SV86.8, SV86.10
unnamed: SV87.1, SV87.3, SV87.5, SV87.7, SV87.9
unnamed: SV87.2, SV87.4, SV87.6, SV87.8, SV87.10
unnamed: SV88.1, SV88.3, SV88.5, SV88.7, SV88.9
unnamed: SV88.2, SV88.4, SV88.6, SV88.8, SV88.10
unnamed: SV89.1, SV89.3, SV89.5, SV89.7, SV89.9
unnamed: SV89.2, SV89.4, SV89.6, SV89.8, SV89.10
unnamed: SV90.1, SV90.3, SV90.5, SV90.7, SV90.9
unnamed: SV90.2, SV90.4, SV90.6, SV90.8, SV90.10
unnamed: SV91.1, SV91.3, SV91.5, SV91.7, SV91.9
unnamed: SV91.2, SV91.4, SV91.6, SV91.8, SV91.10
unnamed: SV92.1, SV92.3, SV92.5, SV92.7, SV92.9
unnamed: SV92.2, SV92.4, SV92.6, SV92.8, SV92.10
unnamed: SV93.1, SV93.3, SV93.5, SV93.7, SV93.9
unnamed: SV93.2, SV93.4, SV93.6, SV93.8, SV93.10
unnamed: SV94.1, SV94.3, SV94.5, SV94.7, SV94.9
unnamed: SV94.2, SV94.4, SV94.6, SV94.8, SV94.10
unnamed: SV95.1, SV95.3, SV95.5, SV95.7, SV95.9
unnamed: SV95.2, SV95.4, SV95.6, SV95.8, SV95.10
unnamed: SV96.1, SV96.3, SV96.5, SV96.7, SV96.9
unnamed: SV96.2, SV96.4, SV96.6, SV96.8, SV96.10
unnamed: SV97.1, SV97.3, SV97.5, SV97.7, SV97.9
unnamed: SV97.2, SV97.4, SV97.6, SV97.8, SV97.10
unnamed: SV98.1, SV98.3, SV98.5, SV98.7, SV98.9
unnamed: SV98.2, SV98.4, SV98.6, SV98.8, SV98.10
unnamed: SV99.1, SV99.3, SV99.5, SV99.7, SV99.9
unnamed: SV99.2, SV99.4, SV99.6, SV99.8, SV99.10
unnamed: SV100.1, SV100.3, SV100.5, SV100.7, SV100.9
unnamed: SV100.2, SV100.4, SV100.6, SV100.8, SV100.10
unnamed: SV101.1, SV101.3, SV101.5, SV101.7, SV101.9
unnamed: SV101.2, SV101.4, SV101.6, SV101.8, SV101.10
unnamed: SV102.1, SV102.3, SV102.5, SV102.7, SV102.9
unnamed: SV102.2, SV102.4, SV102.6, SV102.8, SV102.10
unnamed: SV103.1, SV103.3, SV103.5, SV103.7, SV103.9
unnamed: SV103.2, SV103.4, SV103.6, SV103.8, SV103.10
unnamed: SV104.1, SV104.3, SV104.5, SV104.7, SV104.9
unnamed: SV104.2, SV104.4, SV104.6, SV104.8, SV104.10
unnamed: SV105.1, SV105.3, SV105.5, SV105.7, SV105.9
unnamed: SV105.2, SV105.4, SV105.6, SV105.8, SV105.10
unnamed: SV106.1, SV106.3, SV106.5, SV106.7, SV106.9
unnamed: SV106.2, SV106.4, SV106.6, SV106.8, SV106.10
unnamed: SV107.1, SV107.3, SV107.5, SV107.7, SV107.9
unnamed: SV107.2, SV107.4, SV107.6, SV107.8, SV107.10
unnamed: SV108.1, SV108.3, SV108.5, SV108.7, SV108.9
unnamed: SV108.2, SV108.4, SV108.6, SV108.8, SV108.10
unnamed: SV109.1, SV109.3, SV109.5, SV109.7, SV109.9
unnamed: SV109.2, SV109.4, SV109.6, SV109.8, SV109.10
unnamed: SV110.1, SV110.3, SV110.5, SV110.7, SV110.9
unnamed: SV110.2, SV110.4, SV110.6, SV110.8, SV110.10
unnamed: SV111.1, SV111.3, SV111.5, SV111.7, SV111.9
unnamed: SV111.2, SV111.4, SV111.6, SV111.8, SV111.10
unnamed: SV112.1, SV112.3, SV112.5, SV112.7, SV112.9
unnamed: SV112.2, SV112.4, SV112.6, SV112.8, SV112.10
unnamed: SV113.1, SV113.3, SV113.5, SV113.7, SV113.9
unnamed: SV113.2, SV113.4, SV113.6, SV113.8, SV113.10
unnamed: SV114.1, SV114.3, SV114.5, SV114.7, SV114.9
unnamed: SV114.2, SV114.4, SV114.6, SV114.8, SV114.10
unnamed: SV115.1, SV115.3, SV115.5, SV115.7, SV115.9
unnamed: SV115.2, SV115.4, SV115.6, SV115.8, SV115.10
unnamed: SV116.1, SV116.3, SV116.5, SV116.7, SV116.9
unnamed: SV116.2, SV116.4, SV116.6, SV116.8, SV116.10
unnamed: SV117.1, SV117.3, SV117.5, SV117.7, SV117.9
unnamed: SV117.2, SV117.4, SV117.6, SV117.8, SV117.10
unnamed: SV118.1, SV118.3, SV118.5, SV118.7, SV118.9
unnamed: SV118.2, SV118.4, SV118.6, SV118.8, SV118.10
unnamed: SV119.1, SV119.3, SV119.5, SV119.7, SV119.9
unnamed: SV119.2, SV119.4, SV119.6, SV119.8, SV119.10
unnamed: SV120.1, SV120.3, SV120.5, SV120.7, SV120.9
unnamed: SV120.2, SV120.4, SV120.6, SV120.8, SV120.10
unnamed: SV121.1, SV121.3, SV121.5, SV121.7, SV121.9
unnamed: SV121.2, SV121.4, SV121.6, SV121.8, SV121.10
unnamed: SV122.1, SV122.3, SV122.5, SV122.7, SV122.9
unnamed: SV122.2, SV122.4, SV122.6, SV122.8, SV122.10
unnamed: SV123.1, SV123.3, SV123.5, SV123.7, SV123.9
unnamed: SV123.2, SV123.4, SV123.6, SV123.8, SV123.10
unnamed: SV124.1, SV124.3, SV124.5, SV124.7, SV124.9
unnamed: SV124.2, SV124.4, SV124.6, SV124.8, SV124.10
unnamed: SV126.1, SV126.3, SV126.5, SV126.7, SV126.9
unnamed: SV126.2, SV126.4, SV126.6, SV126.8, SV126.10
unnamed: SV128.1, SV128.3, SV128.5, SV128.7, SV128.9
unnamed: SV128.2, SV128.4, SV128.6, SV128.8, SV128.10
unnamed: SV130.1, SV130.3, SV130.5, SV130.7, SV130.9
unnamed: SV130.2, SV130.4, SV130.6, SV130.8, SV130.10
unnamed: SV132.1, SV132.3, SV132.5, SV132.7, SV132.9
unnamed: SV132.2, SV132.4, SV132.6, SV132.8, SV132.10
unnamed: SV133.1, SV133.3, SV133.5, SV133.7, SV133.9
unnamed: SV133.2, SV133.4, SV133.6, SV133.8, SV133.10
unnamed: SV134.1, SV134.3, SV134.5, SV134.7, SV134.9
unnamed: SV134.2, SV134.4, SV134.6, SV134.8, SV134.10
unnamed: SV135.1, SV135.3, SV135.5, SV135.7, SV135.9
unnamed: SV135.2, SV135.4, SV135.6, SV135.8, SV135.10
unnamed: SV136.1, SV136.3, SV136.5, SV136.7, SV136.9
unnamed: SV136.2, SV136.4, SV136.6, SV136.8, SV136.10
unnamed: SV137.1, SV137.3, SV137.5, SV137.7, SV137.9
unnamed: SV137.2, SV137.4, SV137.6, SV137.8, SV137.10
unnamed: SV138.1, SV138.3, SV138.5, SV138.7, SV138.9
unnamed: SV138.2, SV138.4, SV138.6, SV138.8, SV138.10
unnamed: SV139.1, SV139.3, SV139.5, SV139.7, SV139.9
unnamed: SV139.2, SV139.4, SV139.6, SV139.8, SV139.10
unnamed: SV140.1, SV140.3, SV140.5, SV140.7, SV140.9
unnamed: SV140.2, SV140.4, SV140.6, SV140.8, SV140.10
unnamed: SV141.1, SV141.3, SV141.5, SV141.7, SV141.9
unnamed: SV141.2, SV141.4, SV141.6, SV141.8, SV141.10
unnamed: SV142.1, SV142.3, SV142.5, SV142.7, SV142.9
unnamed: SV142.2, SV142.4, SV142.6, SV142.8, SV142.10
unnamed: SV143.1, SV143.3, SV143.5, SV143.7, SV143.9
unnamed: SV143.2, SV143.4, SV143.6, SV143.8, SV143.10
unnamed: SV144.1, SV144.3, SV144.5, SV144.7, SV144.9
unnamed: SV144.2, SV144.4, SV144.6, SV144.8, SV144.10
unnamed: SV145.1, SV145.3, SV145.5, SV145.7, SV145.9
unnamed: SV145.2, SV145.4, SV145.6, SV145.8, SV145.10
unnamed: SV146.1, SV146.3, SV146.5, SV146.7, SV146.9
unnamed: SV146.2, SV146.4, SV146.6, SV146.8, SV146.10
unnamed: SV147.1, SV147.3, SV147.5, SV147.7, SV147.9
unnamed: SV147.2, SV147.4, SV147.6, SV147.8, SV147.10
unnamed: SV148.1, SV148.3, SV148.5, SV148.7, SV148.9
unnamed: SV148.2, SV148.4, SV148.6, SV148.8, SV148.10
unnamed: SV149.1, SV149.3, SV149.5, SV149.7, SV149.9
unnamed: SV149.2, SV149.4, SV149.6, SV149.8, SV149.10
unnamed: SV150.1, SV150.3, SV150.5, SV150.7, SV150.9
unnamed: SV150.2, SV150.4, SV150.6, SV150.8, SV150.10
unnamed: SV151.1, SV151.3, SV151.5, SV151.7, SV151.9
unnamed: SV151.2, SV151.4, SV151.6, SV151.8, SV151.10
unnamed: SV152.1, SV152.3, SV152.5, SV152.7, SV152.9
unnamed: SV152.2, SV152.4, SV152.6, SV152.8, SV152.10
unnamed: SV153.1, SV153.3, SV153.5, SV153.7, SV153.9
unnamed: SV153.2, SV153.4, SV153.6, SV153.8, SV153.10
unnamed: SV154.1, SV154.3, SV154.5, SV154.7, SV154.9
unnamed: SV154.2, SV154.4, SV154.6, SV154.8, SV154.10
unnamed: SV155.1, SV155.3, SV155.5, SV155.7, SV155.9
unnamed: SV155.2, SV155.4, SV155.6, SV155.8, SV155.10
unnamed: SV156.1, SV156.3, SV156.5, SV156.7, SV156.9
unnamed: SV156.2, SV156.4, SV156.6, SV156.8, SV156.10
unnamed: SV157.1, SV157.3, SV157.5, SV157.7, SV157.9
unnamed: SV157.2, SV157.4, SV157.6, SV157.8, SV157.10
unnamed: SV158.1, SV158.3, SV158.5, SV158.7, SV158.9
unnamed: SV158.2, SV158.4, SV158.6, SV158.8, SV158.10
unnamed: SV159.1, SV159.3, SV159.5, SV159.7, SV159.9
unnamed: SV159.2, SV159.4, SV159.6, SV159.8, SV159.10
unnamed: SV160.1, SV160.3, SV160.5, SV160.7, SV160.9
unnamed: SV160.2, SV160.4, SV160.6, SV160.8, SV160.10
unnamed: SV161.1, SV161.3, SV161.5, SV161.7, SV161.9
unnamed: SV161.2, SV161.4, SV161.6, SV161.8, SV161.10
unnamed: SV162.1, SV162.3, SV162.5, SV162.7, SV162.9
unnamed: SV162.2, SV162.4, SV162.6, SV162.8, SV162.10
unnamed: SV163.1, SV163.3, SV163.5, SV163.7, SV163.9
unnamed: SV163.2, SV163.4, SV163.6, SV163.8, SV163.10
unnamed: SV164.1, SV164.3, SV164.5, SV164.7, SV164.9
unnamed: SV164.2, SV164.4, SV164.6, SV164.8, SV164.10
unnamed: SV165.1, SV165.3, SV165.5, SV165.7, SV165.9
unnamed: SV165.2, SV165.4, SV165.6, SV165.8, SV165.10
unnamed: SV166.1, SV166.3, SV166.5, SV166.7, SV166.9
unnamed: SV166.2, SV166.4, SV166.6, SV166.8, SV166.10
unnamed: SV167.1, SV167.3, SV167.5, SV167.7, SV167.9
unnamed: SV167.2, SV167.4, SV167.6, SV167.8, SV167.10
unnamed: SV168.1, SV168.3, SV168.5, SV168.7, SV168.9
unnamed: SV168.2, SV168.4, SV168.6, SV168.8, SV168.10
unnamed: SV169.1, SV169.3, SV169.5, SV169.7, SV169.9
unnamed: SV169.2, SV169.4, SV169.6, SV169.8, SV169.10
unnamed: SV170.1, SV170.3, SV170.5, SV170.7, SV170.9
unnamed: SV170.2, SV170.4, SV170.6, SV170.8, SV170.10
unnamed: SV171.1, SV171.3, SV171.5, SV171.7, SV171.9
unnamed: SV171.2, SV171.4, SV171.6, SV171.8, SV171.10
unnamed: SV172.1, SV172.3, SV172.5, SV172.7, SV172.9
unnamed: SV172.2, SV172.4, SV172.6, SV172.8, SV172.10
unnamed: SV173.1, SV173.3, SV173.5, SV173.7, SV173.9
unnamed: SV173.2, SV173.4, SV173.6, SV173.8, SV173.10
unnamed: SV174.1, SV174.3, SV174.5, SV174.7, SV174.9
unnamed: SV174.2, SV174.4, SV174.6, SV174.8, SV174.10

Notes on the sheet:
General Prototyping Areas
Douglas Electronics

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