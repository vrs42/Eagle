# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8I/pdp8i-cpu.brd (continued)

Schematic: pdp8i-cpu.sch, sheet 26

Parts:
A05: M113; H807
B04: M115; H807
B05: M216; H807
B06: M113; H807

Connections:
+3V(62): A05.U1, B06.J2 (IN2)
+3V(63): B05.R1 (S), B06.U2 (IN2), B06.V1
+3V(64): B04.F2 (IN3), B05.D1 (S), B06.U1
+3V(65): A05.D1 (IN1), B05.F2 (S), B05.N2 (S); also elsewhere on the board
+3V(66): A05.T2 (IN1); also elsewhere on the board
+3V(67): B04.V2 (IN3); also elsewhere on the board
B_EXT_INST: B04.C1 (IN3); also elsewhere on the board
CINT_: A05.L2 (IN1), B04.D1 (OUT)
CLEAR_IF_: B05.A1 (R); also elsewhere on the board
CUF: B06.K2 (OUT), B06.L1 (IN1)
CUF_: B06.C1 (OUT), B06.D1 (IN1), B06.H2 (IN1); also elsewhere on the board
EXT_GO: B06.D2 (IN1); also elsewhere on the board
GND: A05.C2 (GND), A05.T1 (GND), B04.C2 (GND), B04.T1 (GND), B05.C2 (GND), B05.T1 (GND), B05.T2 (D), B06.C2 (GND), B06.T1 (GND); also elsewhere on the board
IB_TO_IF: B05.D2 (C); also elsewhere on the board
IF_TO_SF: B05.N1 (C); also elsewhere on the board
INITIALIZE_: B05.K2 (R); also elsewhere on the board
I_IOT_: A05.J1 (IN2); also elsewhere on the board
KEY_LAMFTS0_: B06.R2 (IN2); also elsewhere on the board
MB06XMB09: B04.F1 (IN2), B06.B1 (IN2); also elsewhere on the board
MB07: B06.A1 (IN1); also elsewhere on the board
MB07_: B04.A1 (IN1), B04.H1 (IN3); also elsewhere on the board
MB08: B04.E1 (IN1), B06.M1 (IN2); also elsewhere on the board
MB08_: B04.B1 (IN2); also elsewhere on the board
MB09_: A05.B1 (IN2); also elsewhere on the board
MB10_: A05.A1 (IN1); also elsewhere on the board
MB11_: B04.D2 (IN1); also elsewhere on the board
ME05_: A05.K2 (OUT); also elsewhere on the board
unnamed: A05.E1 (IN2), B04.H2 (OUT)
unnamed: A05.D2 (IN1), A05.F1 (OUT)
unnamed: A05.C1 (OUT), A05.E2 (IN2)
unnamed: A05.F2 (OUT), A05.H1 (IN1)
unnamed: A05.U2 (IN2), B04.J1 (OUT)
unnamed: B06.E2 (IN2), B06.F1 (OUT)
unnamed: B06.L2 (IN1), B06.N1 (OUT)
unnamed: B06.M2 (IN2), B06.S1 (OUT)
unnamed: B05.C1 (D), B06.N2 (OUT)
unnamed: B06.F2 (OUT), B06.J1 (IN2)
unnamed: B05.B1 (C), B06.K1 (OUT)
unnamed: B06.S2 (OUT), B06.T2 (IN1)
unnamed: B05.E2 (D), B06.V2 (OUT)
unnamed: A05.K1 (OUT), A05.L1 (IN1)
unnamed: A05.N2 (OUT), A05.P1 (IN1)
unnamed: A05.N1 (OUT), A05.R1 (IN2), B04.P1 (IN1), B04.R1 (IN2)
unnamed: A05.S1 (OUT), B05.M2 (D)
unnamed: B04.S1 (IN3), B05.R2 (0)
unnamed: A05.P2 (IN1), A05.R2 (IN2), B04.U1 (OUT)
unnamed: B04.M2 (OUT), B05.U2 (S)
unnamed: B04.N1 (OUT), B05.S2 (C)
OP2: B04.E2 (IN2); also elsewhere on the board
PC_LOADXSR_ENABLE_: B06.H1 (IN1); also elsewhere on the board
PC_LOAD_: B04.M1 (IN3); also elsewhere on the board
RIB: A05.H2 (IN1); also elsewhere on the board
RMF_: B06.E1 (IN2); also elsewhere on the board
SF_ENABLE: B06.R1 (IN2); also elsewhere on the board
SINT: A05.V2 (OUT), B04.L2 (IN3)
SKIP_: B04.U2 (IN2); also elsewhere on the board
SKIP_OR: B04.V1 (OUT); also elsewhere on the board
S_UF: A05.J2 (IN2), B05.S1 (1), B06.P1 (IN1)
TP2E_: B04.K1 (IN1), B04.L1 (IN2); also elsewhere on the board
TP3: B04.K2 (IN2), B05.L2 (C); also elsewhere on the board
UB: B05.E1 (1), B06.P2 (IN1)
UF: A05.M1 (IN2), B05.H2 (1), B05.P1 (D)
UF_: B05.J2 (0); also elsewhere on the board
UINT: A05.M2 (IN2), B04.J2 (IN1), B05.P2 (1)
UINT_: A05.S2 (OUT); also elsewhere on the board
USF_: B04.T2 (IN1), B05.V1 (0)
VCC: A05.A2 (VCC), B04.A2 (VCC), B05.A2 (VCC), B06.A2 (VCC); also elsewhere on the board

Notes on the sheet:
NOTE:
8i-0-10
8i-0-12
8i-0-5
8i-0-6
PIN
PRINT
LOCATION
J13U2
C-6
A-6
B-4
D-2
D-3
(Locations refer to DEC drawings.)
F19N1
E27L1
F25S2
F25S1
D-BS-kt8i-0-1 Time-share Option

Schematic: pdp8i-cpu.sch, sheet 27

Parts:
C13: M310; H807
C18: M113; H807
C22: M216; H807
D12, D13, D14, D15, D16: M113; H807
D17, D18, D19: M115; H807
D20, D21: M117; H807
D22: M617; H807
D23: M160; H807
D24: M216; H807
E22, E24: M113; H807

Connections:
+3V(24): C18.H2 (IN1), C18.U1; also elsewhere on the board
+3V(28): D12.E1 (IN2), D12.M1 (IN2), D12.U1, D13.J1 (IN2), D13.J2 (IN2); also elsewhere on the board
+3V(29): D14.P1 (IN1), D15.D2 (IN1), D15.H2 (IN1), D15.M2 (IN2), D15.P1 (IN1), D15.U1, D15.U2 (IN2)
+3V(30): D16.A1 (IN1), D16.D1 (IN1), D16.D2 (IN1), D16.M2 (IN2), D16.R1 (IN2), D16.R2 (IN2), D16.U1, D16.U2 (IN2)
+3V(31): D22.H1 (IN2), D22.J1 (IN3), D22.K1 (IN4), D22.L2 (IN2), D22.M1 (IN1), D22.M2 (IN3), D22.N1 (IN2), D22.N2 (IN4), D22.T2 (IN3), E22.V1
+3V(32): D23.M1 (IN5A), D24.D1 (S), D24.F2 (S), D24.K1 (S), D24.N2 (S), E24.U1; also elsewhere on the board
AC00: D15.E1 (IN2), D18.J2 (IN1); also elsewhere on the board
AC00_: D15.A1 (IN1); also elsewhere on the board
AC01: D14.L1 (IN1), D15.B1 (IN2); also elsewhere on the board
AC01_: D15.D1 (IN1), D16.H2 (IN1); also elsewhere on the board
AC02: D16.J2 (IN2); also elsewhere on the board
AC02_: D14.M1 (IN2), D20.D1 (IN4); also elsewhere on the board
AC03_: D19.K1 (IN1), D20.C1 (IN3); also elsewhere on the board
AC_TO_MQ_ENABLE: D15.S1 (OUT); also elsewhere on the board
AC_TO_MQ_ENABLE_: D15.R1 (IN2), D21.L1 (OUT); also elsewhere on the board
ADDER_L: D19.F1 (IN2); also elsewhere on the board
ASR_ENABLE: D15.V2 (OUT), D18.K2 (IN2); also elsewhere on the board
ASR_L_SET_: D18.M2 (OUT); also elsewhere on the board
B_EAE_ON: D13.B1 (IN2), D13.K1 (OUT), D17.C1 (IN3), D17.K1 (IN1), D17.L2 (IN3), D18.A1 (IN1), D18.P1 (IN1), D18.R2 (IN3), D20.E2 (IN2), D20.J1 (IN3); also elsewhere on the board
B_EXECUTE: D13.M2 (IN2), D14.E2 (IN2), D21.H2 (IN4); also elsewhere on the board
B_FETCH: D20.M1 (IN1); also elsewhere on the board
B_POWER_CLEAR_: D24.K2 (R); also elsewhere on the board
DIV_LAST: D12.A1 (IN1), D13.E2 (IN2), D16.K1 (OUT), D20.M2 (IN3), D23.E1 (IN2A)
DIV_LAST_: D12.C1 (OUT), D12.D2 (IN1), D12.L2 (IN1), D17.J2 (IN1), D20.H2 (IN4)
DVI: D12.B1 (IN2), D16.M1 (IN2), D16.S2 (OUT), D17.F1 (IN2), D17.M1 (IN3), D20.N2 (IN4), D23.F1 (IN2B)
DVI_: D16.P2 (IN1), D17.B1 (IN2), D19.V1 (OUT); also elsewhere on the board
EAE_ACBAR_ENABLE_: D13.A1 (IN1), D17.N1 (OUT), D17.P1 (IN1); also elsewhere on the board
EAE_AC_ENABLE_: D13.C1 (OUT); also elsewhere on the board
EAE_BEGIN: D12.R2 (IN2), D14.H1 (IN1), D14.K2 (OUT), D17.V2 (IN3)
EAE_COMPLETE_: C22.T2 (D), D15.J2 (IN2), D23.R1 (OUT)
EAE_END: C22.V2 (1); also elsewhere on the board
EAE_EXECUTE_: D13.N2 (OUT); also elsewhere on the board
EAE_E_SET_: D13.N1 (OUT); also elsewhere on the board
EAE_INST: D13.D1 (IN1), D13.K2 (OUT), D13.M1 (IN2), D14.R2 (IN2), D18.L1 (IN2), D20.U2 (IN4)
EAE_IR0: D18.B1 (IN2), D20.R2 (IN1), D24.E1 (1)
EAE_IR0_: D15.H1 (IN1), D19.N2 (IN1), D19.P1 (IN1), D19.T2 (IN1), D20.F1 (IN1), D24.F1 (0)
EAE_IR1: D15.J1 (IN2), D17.A1 (IN1), D18.C1 (IN3), D19.R1 (IN2), D19.U2 (IN2), D24.H2 (1)
EAE_IR1_: D19.P2 (IN2), D20.S2 (IN2), D24.J2 (0)
EAE_IR2: D19.R2 (IN3), D19.V2 (IN3), D24.L1 (1)
EAE_IR2_: D18.L2 (IN3), D19.S1 (IN3), D20.T2 (IN3), D24.M1 (0); also elsewhere on the board
EAE_IR_CLEAR_: D24.A1 (R); also elsewhere on the board
EAE_LEFT_SHIFT_ENABLE_: D20.J2 (OUT); also elsewhere on the board
EAE_L_DISABLE: D17.U1 (OUT); also elsewhere on the board
EAE_MEM_ENABLE_: D20.L1 (OUT); also elsewhere on the board
EAE_MQ0BAR_ENABLE_: D18.U1 (OUT); also elsewhere on the board
EAE_MQ0_ENABLE_: D18.S2 (OUT); also elsewhere on the board
EAE_NO_SHIFT_ENABLE: D17.M2 (OUT); also elsewhere on the board
EAE_ON: D24.P1 (D), D24.P2 (1); also elsewhere on the board
EAE_ON_: D13.H1 (IN1), D21.E2 (IN2), D24.R2 (0); also elsewhere on the board
EAE_RIGHT_SHIFT_ENABLE_: D17.D1 (OUT), D20.D2 (IN1); also elsewhere on the board
EAE_RUN: C22.U2 (S), D12.M2 (IN2), D14.A1 (IN1), D15.M1 (IN2), D24.S1 (1)
EAE_SET_: D14.K1 (OUT); also elsewhere on the board
EAE_START_: D14.E1 (IN2), D17.V1 (OUT), D24.R1 (S); also elsewhere on the board
EAE_TG: D22.P1 (IN3), D22.R2 (IN1), D24.V2 (1)
EAE_TP: C13.J1 (OUT), C22.S2 (C), D14.B1 (IN2)
EAE_TP_: D12.P1 (IN1), D14.C1 (OUT), D14.D1 (IN1); also elsewhere on the board
GND: C13.C2 (GND), C13.T1 (GND), C18.C2 (GND), C18.T1 (GND), C22.C2 (GND), C22.T1 (GND), D12.C2 (GND), D12.T1 (GND), D13.C2 (GND), D13.T1 (GND), D14.C2 (GND), D14.T1 (GND), D15.C2 (GND), D15.T1 (GND), D16.C2 (GND), D16.T1 (GND), D17.C2 (GND), D17.T1 (GND), D18.C2 (GND), D18.T1 (GND), D19.C2 (GND), D19.T1 (GND), D20.C2 (GND), D20.T1 (GND), D21.C2 (GND), D21.T1 (GND), D22.C2 (GND), D22.T1 (GND), D23.C2 (GND), D23.H1 (IN3A), D23.J1 (IN3B), D23.T1 (GND), D24.C2 (GND), D24.T1 (GND), E22.C2 (GND), E22.T1 (GND), E24.C2 (GND), E24.T1 (GND); also elsewhere on the board
LOW_AC0: D21.D1 (IN4); also elsewhere on the board
MB03: D20.P1 (IN3); also elsewhere on the board
MB04_: D21.J1 (IN3); also elsewhere on the board
MB05: D18.D2 (IN1); also elsewhere on the board
MB06: D18.H1 (IN3); also elsewhere on the board
MB07: D18.K1 (IN1), D21.H1 (IN2); also elsewhere on the board
MB08: D24.C1 (D); also elsewhere on the board
MB09: D13.E1 (IN2), D24.E2 (D); also elsewhere on the board
MB09_: D13.P1 (IN1); also elsewhere on the board
MB10: D24.J1 (D); also elsewhere on the board
MB10_: D13.R1 (IN2); also elsewhere on the board
MB11: D18.E1 (IN1), D18.F2 (IN3), D20.R1 (IN4), D21.F1 (IN1); also elsewhere on the board
MB_TO_SC_ENABLE: D15.N2 (OUT); also elsewhere on the board
MFTS2_: D12.R1 (IN2); also elsewhere on the board
MID_AC0: D19.M1 (IN3), D20.B1 (IN2); also elsewhere on the board
MQ00: D18.S1 (IN3); also elsewhere on the board
MQ00_: D18.N2 (IN1), D21.K2 (IN1); also elsewhere on the board
MQ01_: D21.L2 (IN2); also elsewhere on the board
MQ02_: D21.M2 (IN3); also elsewhere on the board
MQ03_: D21.N2 (IN4); also elsewhere on the board
MQ04_: D21.M1 (IN1); also elsewhere on the board
MQ05_: D21.N1 (IN2); also elsewhere on the board
MQ06_: D21.P1 (IN3); also elsewhere on the board
MQ07_: D21.R1 (IN4); also elsewhere on the board
MQ08_: D21.R2 (IN1); also elsewhere on the board
MQ09_: D21.S2 (IN2); also elsewhere on the board
MQ10: D13.D2 (IN1), D23.V1 (IN2A); also elsewhere on the board
MQ10_: D12.E2 (IN2), D21.T2 (IN3); also elsewhere on the board
MQ11: D20.K2 (IN1), D23.U1 (IN1B); also elsewhere on the board
MQ11_: D13.U2 (IN2), D15.P2 (IN1), D21.U2 (IN4), D23.U2 (IN2B); also elsewhere on the board
MQ_ENABLE: D22.L1 (OUT); also elsewhere on the board
MQ_LOAD: D22.S1 (OUT); also elsewhere on the board
MQ_LOW_AC0: D15.F2 (OUT), D19.L1 (IN2), D20.A1 (IN1)
MUY: D15.R2 (IN2), D16.S1 (OUT), D23.A1 (IN1A)
MUY_: D16.P1 (IN1), D19.U1 (OUT)
MUY_DVI_: D15.K1 (OUT), D21.D2 (IN1)
unnamed: D16.H1 (IN1), D19.J1 (OUT)
unnamed: D16.J1 (IN2), D19.M2 (OUT)
unnamed: D19.E2 (IN2), D19.N1 (OUT)
unnamed: D16.K2 (OUT), D19.D2 (IN1)
unnamed: D14.N1 (OUT), D19.F2 (IN3)
unnamed: D19.H2 (OUT), D23.P1 (IN5C)
unnamed: D16.B1 (IN2), D21.P2 (OUT)
unnamed: D16.E1 (IN2), D21.S1 (OUT)
unnamed: D16.E2 (IN2), D21.V2 (OUT)
unnamed: D16.C1 (OUT), D21.A1 (IN1)
unnamed: D16.F2 (OUT), D21.C1 (IN3)
unnamed: D16.F1 (OUT), D21.B1 (IN2)
unnamed: D15.E2 (IN2), D21.E1 (OUT)
unnamed: D17.E2 (IN2), D20.E1 (OUT)
unnamed: D15.C1 (OUT), D17.D2 (IN1)
unnamed: D15.F1 (OUT), D17.F2 (IN3)
unnamed: D15.L2 (IN1), D21.J2 (OUT)
unnamed: D17.J1 (OUT), D17.K2 (IN2), D20.F2 (IN3)
unnamed: D17.L1 (IN2), D17.S2 (OUT)
unnamed: D15.S2 (OUT), D20.K1 (IN4)
unnamed: D17.P2 (IN2), D23.V2 (OUT)
unnamed: D20.H1 (IN2), D20.P2 (OUT)
unnamed: D12.D1 (IN1), D12.F2 (OUT)
unnamed: D13.F2 (OUT), D17.R2 (IN3)
unnamed: D12.F1 (OUT), D23.S1 (IN1A)
unnamed: D15.K2 (OUT), D15.L1 (IN1)
unnamed: D13.F1 (OUT), D17.R1 (IN2)
unnamed: D15.T2 (IN1), D17.S1 (IN3), D18.D1 (OUT)
unnamed: D18.H2 (OUT), D22.F1 (IN1)
unnamed: D18.N1 (OUT), D22.R1 (IN4)
unnamed: D12.S2 (OUT), D22.U2 (IN4)
unnamed: C13.E1 (IN), C13.S2
unnamed: C13.H1 (IN), C13.P2
unnamed: D18.J1 (OUT), D22.K2 (IN1)
unnamed: D14.V2 (OUT), D22.S2 (IN2)
unnamed: D14.S1 (OUT), D24.B1 (C), D24.D2 (C), D24.H1 (C)
unnamed: D14.R1 (IN2), D14.S2 (OUT)
unnamed: D14.F2 (OUT), D14.J2 (IN2)
unnamed: D12.N2 (OUT), D24.T2 (D)
unnamed: D12.N1 (OUT), D24.U2 (S)
unnamed: D12.S1 (OUT), D24.S2 (C)
unnamed: D14.H2 (IN1), D14.N2 (OUT)
unnamed: C13.H2, D14.F1 (OUT), D24.L2 (C)
unnamed: C13.F1 (OUT), D12.L1 (IN1), D24.N1 (C)
unnamed: D15.N1 (OUT), D24.M2 (D)
unnamed: D13.H2 (IN1), D20.S1 (OUT)
unnamed: D13.L1 (IN1), D13.S1 (OUT)
unnamed: D13.V2 (OUT), D16.L1 (IN1)
unnamed: D16.L2 (IN1), D16.N1 (OUT), D18.P2 (IN2)
unnamed: D16.N2 (OUT), D18.R1 (IN2)
NMI: D14.M2 (IN2), D14.U2 (IN2), D16.V2 (OUT), D23.N1 (IN5B)
NMI_: D16.T2 (IN1), D20.V2 (OUT)
NORM: C18.J2 (IN2), D17.H2 (OUT)
NORM_: C18.K2 (OUT), D14.L2 (IN1)
OP2: D18.E2 (IN2), D18.F1 (IN2), D21.K1 (IN4); also elsewhere on the board
OPR: D13.L2 (IN1), D14.D2 (IN1), D20.N1 (IN2), D21.F2 (IN3); also elsewhere on the board
SC0: D23.L1 (IN4B); also elsewhere on the board
SC0_3_0: D13.P2 (IN1), D19.E1 (IN1); also elsewhere on the board
SC0_3_0_: D17.N2 (IN1); also elsewhere on the board
SC1: D17.E1 (IN1), D19.J2 (IN1), D20.L2 (IN2), D23.B1 (IN1B); also elsewhere on the board
SC2: D17.H1 (IN3), D19.L2 (IN3); also elsewhere on the board
SC3: D23.C1 (IN1C); also elsewhere on the board
SC4: D19.K2 (IN2), D23.D1 (IN1D); also elsewhere on the board
SC4_: D13.R2 (IN2), D19.H1 (IN3); also elsewhere on the board
SCL_: D14.J1 (IN2), D17.T2 (IN1), D19.S2 (OUT)
SC_0_: D13.S2 (OUT), D13.T2 (IN1)
SC_ENABLE: D22.P2 (OUT); also elsewhere on the board
SC_FULL: D23.K1 (IN4A); also elsewhere on the board
SC_LOAD: D22.V2 (OUT); also elsewhere on the board
TP3: D12.P2 (IN1), D14.P2 (IN1), D14.T2 (IN1), D17.U2 (IN2), D18.M1 (IN3); also elsewhere on the board
VCC: C13.A2 (VCC), C18.A2 (VCC), C22.A2 (VCC), D12.A2 (VCC), D13.A2 (VCC), D14.A2 (VCC), D15.A2 (VCC), D16.A2 (VCC), D17.A2 (VCC), D18.A2 (VCC), D19.A2 (VCC), D20.A2 (VCC), D21.A2 (VCC), D22.A2 (VCC), D23.A2 (VCC), D24.A2 (VCC), E22.A2 (VCC), E24.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-ke8i-0-2 EAE Control

Schematic: pdp8i-cpu.sch, sheet 28

Parts:
B21: M113; H807
C14, C15, C16, C17, C18: M113; H807
C19, C20, C21: M115; H807
C22, C23, C24: M216; H807
C40: M900; H807
D12: M113; H807
D19: M115; H807
D22: M617; H807
D23: M160; H807
E40: M900; H807
F40: M900; H807

Connections:
+3V(24): C18.A1 (IN1), C18.D1 (IN1), C18.D2 (IN1), C18.R2 (IN2), C18.U2 (IN2); also elsewhere on the board
+3V(25): B21.V1, C22.A1 (R), C22.D1 (S), C22.F2 (S), C22.K1 (S), C22.K2 (R), C22.N2 (S), C22.R1 (S)
+3V(26): C23.A1 (R), C23.D1 (S), C23.F2 (S), C23.K1 (S), C23.K2 (R), C23.N2 (S), C23.R1 (S), C23.U2 (S), D22.U1
+3V(27): C24.A1 (R), C24.D1 (S), C24.F2 (S), C24.K1 (S), C24.K2 (R), C24.N2 (S), C24.R1 (S), C24.U2 (S), D22.V1
+3V(28): D12.J2 (IN2), D12.T2 (IN1); also elsewhere on the board
+3V(32): D23.D2 (IN1A), D23.E2 (IN1B), D23.N2 (IN4A), D23.P2 (IN4B), D23.R2 (IN4C); also elsewhere on the board
AC00: C14.E1 (IN2); also elsewhere on the board
AC01: C14.J2 (IN2); also elsewhere on the board
AC02: C14.R1 (IN2); also elsewhere on the board
AC03: C15.E1 (IN2); also elsewhere on the board
AC04: C15.J2 (IN2); also elsewhere on the board
AC05: C15.R1 (IN2); also elsewhere on the board
AC06: C16.E1 (IN2); also elsewhere on the board
AC07: C16.J2 (IN2); also elsewhere on the board
AC08: C16.R1 (IN2); also elsewhere on the board
AC09: C17.E1 (IN2); also elsewhere on the board
AC10: C17.J2 (IN2); also elsewhere on the board
AC11: C17.R1 (IN2); also elsewhere on the board
AC_TO_MQ_ENABLE: C14.D1 (IN1), C14.H2 (IN1), C14.P1 (IN1), C15.D1 (IN1), C15.H2 (IN1), C15.P1 (IN1), C16.D1 (IN1), C16.H2 (IN1), C16.P1 (IN1), C17.D1 (IN1), C17.H2 (IN1), C17.P1 (IN1); also elsewhere on the board
ADDER11_: C14.B1 (IN2); also elsewhere on the board
ADDER_L: C18.V2 (OUT), D23.L2 (IN3A); also elsewhere on the board
ADDER_L_: C18.T2 (IN1), D23.K2 (IN2B); also elsewhere on the board
BB_LEFT_SHIFT: C16.D2 (IN1), C16.L1 (IN1), C16.P2 (IN1), C17.D2 (IN1), C17.L1 (IN1), C17.P2 (IN1), D12.V2 (OUT)
B_EAE_ON: D12.J1 (IN2); also elsewhere on the board
B_LEFT_SHIFT: C14.D2 (IN1), C14.L1 (IN1), C14.P2 (IN1), C15.D2 (IN1), C15.L1 (IN1), C15.P2 (IN1), D12.K2 (OUT)
DVI_: D23.S2 (IN4D); also elsewhere on the board
EAE_ON: C18.L2 (IN1), C21.A1 (IN1), C21.D2 (IN1), C21.E1 (IN1), C21.J2 (IN1), C21.K1 (IN1), C21.N2 (IN1), C21.R1 (IN2), C21.T2 (IN1); also elsewhere on the board
EAE_RIGHT_SHIFT_ENABLE_: D12.H1 (IN1); also elsewhere on the board
EAE_TP_: D22.D2 (IN1); also elsewhere on the board
GND: B21.C2 (GND), B21.T1 (GND), C14.C2 (GND), C14.T1 (GND), C15.C2 (GND), C15.T1 (GND), C16.C2 (GND), C16.T1 (GND), C17.C2 (GND), C17.T1 (GND), C18.C2 (GND), C18.T1 (GND), C19.C2 (GND), C19.T1 (GND), C20.C2 (GND), C20.T1 (GND), C21.C2 (GND), C21.T1 (GND), C22.C2 (GND), C22.T1 (GND), C23.C2 (GND), C23.T1 (GND), C24.C2 (GND), C24.T1 (GND), D12.C2 (GND), D12.T1 (GND), D19.C2 (GND), D19.T1 (GND), D22.C2 (GND), D22.T1 (GND), D23.C2 (GND), D23.T1 (GND); also elsewhere on the board
LEFT_SHIFT_: D12.H2 (IN1), D12.K1 (OUT), D12.U2 (IN2)
MB07_: C14.U2 (IN2); also elsewhere on the board
MB08_: C15.U2 (IN2); also elsewhere on the board
MB09_: C16.U2 (IN2); also elsewhere on the board
MB10_: C17.U2 (IN2); also elsewhere on the board
MB11_: C18.R1 (IN2); also elsewhere on the board
MB_TO_SC_ENABLE: C14.T2 (IN1), C15.T2 (IN1), C16.T2 (IN1), C17.T2 (IN1), C18.P1 (IN1); also elsewhere on the board
MQ00: C14.J1 (IN2), C23.E1 (1); also elsewhere on the board
MQ00_: C23.F1 (0), E40.S2; also elsewhere on the board
MQ01: C14.E2 (IN2), C14.M2 (IN2), C23.H2 (1); also elsewhere on the board
MQ01_: C23.J2 (0), E40.M2; also elsewhere on the board
MQ02: C14.M1 (IN2), C15.B1 (IN2), C23.L1 (1); also elsewhere on the board
MQ02_: C23.M1 (0), E40.N2; also elsewhere on the board
MQ03: C14.R2 (IN2), C15.J1 (IN2), C23.P2 (1); also elsewhere on the board
MQ03_: C23.R2 (0), E40.L2; also elsewhere on the board
MQ04: C15.E2 (IN2), C15.M2 (IN2), C23.S1 (1); also elsewhere on the board
MQ04_: C23.U1 (0), E40.F1; also elsewhere on the board
MQ05: C15.M1 (IN2), C16.B1 (IN2), C23.V2 (1); also elsewhere on the board
MQ05_: C23.V1 (0), E40.H1; also elsewhere on the board
MQ06: C15.R2 (IN2), C16.J1 (IN2), C24.E1 (1); also elsewhere on the board
MQ06_: C24.F1 (0), F40.S2; also elsewhere on the board
MQ07: C16.E2 (IN2), C16.M2 (IN2), C24.H2 (1); also elsewhere on the board
MQ07_: C24.J2 (0), F40.M2; also elsewhere on the board
MQ08: C16.M1 (IN2), C17.B1 (IN2), C24.L1 (1); also elsewhere on the board
MQ08_: C24.M1 (0), F40.N2; also elsewhere on the board
MQ09: C16.R2 (IN2), C17.J1 (IN2), C24.P2 (1); also elsewhere on the board
MQ09_: C24.R2 (0), F40.L2; also elsewhere on the board
MQ10: C17.E2 (IN2), C17.M2 (IN2), C24.S1 (1); also elsewhere on the board
MQ10_: C24.U1 (0), F40.F1; also elsewhere on the board
MQ11: C17.M1 (IN2), C24.V2 (1), D23.J2 (IN2A); also elsewhere on the board
MQ11_: C24.V1 (0), D23.M2 (IN3B), F40.H1; also elsewhere on the board
MQ_LOAD: C23.B1 (C), C23.D2 (C), C23.H1 (C), C23.L2 (C), C23.N1 (C), C23.S2 (C), C24.B1 (C), C24.D2 (C), C24.H1 (C), C24.L2 (C), C24.N1 (C), C24.S2 (C); also elsewhere on the board
unnamed: C14.F1 (OUT), C19.B1 (IN2)
unnamed: C14.K2 (OUT), C19.E2 (IN2)
unnamed: C14.S1 (OUT), C19.F1 (IN2)
unnamed: C15.F1 (OUT), C19.K2 (IN2)
unnamed: C15.K2 (OUT), C19.L1 (IN2)
unnamed: C15.S1 (OUT), C19.P2 (IN2)
unnamed: C16.F1 (OUT), C19.R1 (IN2)
unnamed: C16.K2 (OUT), C19.U2 (IN2)
unnamed: C16.S1 (OUT), C20.B1 (IN2)
unnamed: C17.F1 (OUT), C20.E2 (IN2)
unnamed: C17.K2 (OUT), C20.F1 (IN2)
unnamed: C17.S1 (OUT), C20.K2 (IN2)
unnamed: C14.C1 (OUT), C19.A1 (IN1)
unnamed: C14.F2 (OUT), C19.C1 (IN3)
unnamed: C14.K1 (OUT), C19.D2 (IN1)
unnamed: C14.N1 (OUT), C19.F2 (IN3)
unnamed: C14.N2 (OUT), C19.E1 (IN1)
unnamed: C14.S2 (OUT), C19.H1 (IN3)
unnamed: C15.C1 (OUT), C19.J2 (IN1)
unnamed: C15.F2 (OUT), C19.L2 (IN3)
unnamed: C15.K1 (OUT), C19.K1 (IN1)
unnamed: C15.N1 (OUT), C19.M1 (IN3)
unnamed: C15.N2 (OUT), C19.N2 (IN1)
unnamed: C15.S2 (OUT), C19.R2 (IN3)
unnamed: C16.C1 (OUT), C19.P1 (IN1)
unnamed: C16.F2 (OUT), C19.S1 (IN3)
unnamed: C16.K1 (OUT), C19.T2 (IN1)
unnamed: C16.N1 (OUT), C19.V2 (IN3)
unnamed: C16.N2 (OUT), C20.A1 (IN1)
unnamed: C16.S2 (OUT), C20.C1 (IN3)
unnamed: C17.C1 (OUT), C20.D2 (IN1)
unnamed: C17.F2 (OUT), C20.F2 (IN3)
unnamed: C17.K1 (OUT), C20.E1 (IN1)
unnamed: C17.N1 (OUT), C20.H1 (IN3)
unnamed: C17.N2 (OUT), C20.J2 (IN1)
unnamed: C17.S2 (OUT), C20.L2 (IN3)
unnamed: C19.D1 (OUT), C23.C1 (D)
unnamed: C19.H2 (OUT), C23.E2 (D)
unnamed: C19.J1 (OUT), C23.J1 (D)
unnamed: C19.M2 (OUT), C23.M2 (D)
unnamed: C19.N1 (OUT), C23.P1 (D)
unnamed: C19.S2 (OUT), C23.T2 (D)
unnamed: C19.U1 (OUT), C24.C1 (D)
unnamed: C19.V1 (OUT), C24.E2 (D)
unnamed: C20.D1 (OUT), C24.J1 (D)
unnamed: C20.H2 (OUT), C24.M2 (D)
unnamed: C20.J1 (OUT), C24.P1 (D)
unnamed: C20.M2 (OUT), C24.T2 (D)
unnamed: C20.L1 (IN2), C21.H2 (OUT)
unnamed: C20.K1 (IN1), C21.D1 (OUT)
unnamed: C14.V2 (OUT), C20.M1 (IN3)
unnamed: C20.N1 (OUT), C22.C1 (D)
unnamed: C18.L1 (IN1), C18.N2 (OUT)
unnamed: C18.M1 (IN2), C18.S1 (OUT)
unnamed: C20.S2 (OUT), C22.E2 (D)
unnamed: C20.U1 (OUT), C22.J1 (D)
unnamed: C20.V1 (OUT), C22.M2 (D)
unnamed: C18.N1 (OUT), C22.P1 (D)
unnamed: C20.N2 (IN1), C21.J1 (OUT)
unnamed: C20.P1 (IN1), C21.N1 (OUT)
unnamed: C20.T2 (IN1), C21.U1 (OUT)
unnamed: C20.P2 (IN2), C21.M2 (OUT)
unnamed: C20.R1 (IN2), C21.S2 (OUT)
unnamed: C20.U2 (IN2), C21.V1 (OUT)
unnamed: C15.V2 (OUT), C20.R2 (IN3)
unnamed: C16.V2 (OUT), C20.S1 (IN3)
unnamed: C17.V2 (OUT), C20.V2 (IN3)
unnamed: C18.B1 (IN2), C21.E2 (IN2), D22.E1 (OUT)
unnamed: C18.E1 (IN2), C21.K2 (IN2), D19.D1 (OUT)
unnamed: C18.F1 (OUT), C21.F1 (IN2)
unnamed: C18.E2 (IN2), C18.K1 (OUT), C21.P2 (IN2)
unnamed: C18.F2 (OUT), C21.L1 (IN2)
unnamed: C17.R2 (IN2), D23.T2 (OUT)
RIGHT_SHIFT: C14.A1 (IN1), C14.H1 (IN1), C14.L2 (IN1), C15.A1 (IN1), C15.H1 (IN1), C15.L2 (IN1), C16.A1 (IN1), C16.H1 (IN1), C16.L2 (IN1), C17.A1 (IN1), C17.H1 (IN1), C17.L2 (IN1); also elsewhere on the board
SC0: C21.F2 (IN3), C22.E1 (1); also elsewhere on the board
SC0_: C21.C1 (IN3), C22.F1 (0), C40.S2
SC0_3_0: C18.S2 (OUT), D23.F2 (IN1C); also elsewhere on the board
SC0_3_0_: C18.P2 (IN1), D22.J2 (OUT); also elsewhere on the board
SC1: C21.L2 (IN3), C22.H2 (1), D22.A1 (IN1); also elsewhere on the board
SC1_: C21.H1 (IN3), C22.J2 (0), C40.M2, D22.E2 (IN2)
SC2: C21.R2 (IN3), C22.L1 (1), D19.A1 (IN1), D22.B1 (IN2); also elsewhere on the board
SC2_: C21.M1 (IN3), C22.M1 (0), C40.N2, D22.F2 (IN3)
SC3: C18.H1 (IN1), C21.U2 (IN2), C22.P2 (1), D19.B1 (IN2), D22.C1 (IN3); also elsewhere on the board
SC3_: C21.P1 (IN1), C22.R2 (0), C40.L2, D22.H2 (IN4)
SC4: C18.J1 (IN2), C21.S1 (IN3), C22.S1 (1), D19.C1 (IN3), D22.D1 (IN4); also elsewhere on the board
SC4_: C18.M2 (IN2), C21.V2 (IN3), C22.U1 (0), C40.F1, D23.H2 (IN1D); also elsewhere on the board
SC_FULL: C18.C1 (OUT), C21.B1 (IN2); also elsewhere on the board
SC_LOAD: C22.B1 (C), C22.D2 (C), C22.H1 (C), C22.L2 (C), C22.N1 (C); also elsewhere on the board
VCC: B21.A2 (VCC), C14.A2 (VCC), C15.A2 (VCC), C16.A2 (VCC), C17.A2 (VCC), C18.A2 (VCC), C19.A2 (VCC), C20.A2 (VCC), C21.A2 (VCC), C22.A2 (VCC), C23.A2 (VCC), C24.A2 (VCC), D12.A2 (VCC), D19.A2 (VCC), D22.A2 (VCC), D23.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-ke8i-0-3 Multiplier Quot. and Step Counter

Schematic: pdp8i-cpu.sch, sheet 29

Parts:
C07: M661; H807
C08: M660; H807
C09, C10: M113; H807
C11: M115; H807
D04: W011; H807
D05: M516; H807
D07: M113; H807
D09: M115; H807
D10: M117; H807
D11: M216; H807

Connections:
+3V(23): C10.B1 (IN2), C10.D1 (IN1), C10.D2 (IN1), C10.H2 (IN1), C10.J1 (IN2), C10.U2 (IN2), C11.B1 (IN2), D10.B1 (IN2), D10.C1 (IN3), D10.U1, D11.A1 (R)
+3V(57): C07.F2 (IN3), C07.H2 (IN2), C07.N2 (IN2), C07.P2 (IN3), C08.H2 (IN1), C08.N2 (IN1), C08.U2 (IN1), C09.E1 (IN2), C09.J1 (IN2), C09.M1 (IN2), C09.M2 (IN2), C09.R1 (IN2), C09.R2 (IN2), D10.V1, D11.K2 (R), D11.N2 (S)
+3V(58): D07.E2 (IN2), D09.H1 (IN3), D09.R1 (IN2), D09.V2 (IN3), D10.E2 (IN2); also elsewhere on the board
-15V: C07.B2 (-15V); also elsewhere on the board
BSTLR: C07.S2 (OUT), D04.M2
BTP3: C08.D2 (OUT), D04.E2
B_C_: C07.K2 (OUT), D04.K2
B_DC_INST: C08.S2 (OUT), D04.P2
B_FETCH: D10.N2 (IN4); also elsewhere on the board
B_LINE_HOLD_: C07.D2 (OUT), D04.D2
B_MEM_TO_LSR: C08.K2 (OUT), D04.H2
B_R0_: D04.V2, D05.D2 (IN), D05.E2 (IN2), D05.F2 (IN3), D05.H2 (IN4)
C: C10.P2 (IN1), C11.E1 (IN1), D09.E2 (IN2), D10.N1 (IN2), D10.S2 (IN2), D11.J2 (0)
CSR_ENABLE_: C11.E2 (IN2), D07.F1 (OUT)
C_: C07.M2 (IN1), D09.N2 (IN1), D11.H2 (1)
C_NO_SHIFT_: D07.C1 (OUT); also elsewhere on the board
C_SET_: C11.A1 (IN1), C11.R2 (IN3), D10.J2 (OUT), D11.E2 (D)
DC_INST_: C08.V2 (IN2), D09.J1 (OUT)
GND: C07.C2 (GND), C08.C2 (GND), C09.C2 (GND), C09.T1 (GND), C10.C2 (GND), C10.T1 (GND), C11.C2 (GND), C11.T1 (GND), D04.C2 (GND), D04.F2 (GND), D04.J2 (GND), D04.L2 (GND), D04.N2 (GND), D04.R2 (GND), D04.U2 (GND), D05.C2 (GND), D05.T1 (GND), D07.C2 (GND), D07.T1 (GND), D09.C2 (GND), D09.T1 (GND), D10.C2 (GND), D10.T1 (GND), D11.C2 (GND), D11.T1 (GND); also elsewhere on the board
HS: D07.B1 (IN2), D11.P2 (1)
HS_: C09.B1 (IN2), C11.F1 (IN2), D07.E1 (IN2), D11.R2 (0)
IOT: D09.F1 (IN2), D10.K2 (IN1); also elsewhere on the board
LHS: D05.E1 (OUT), D11.M2 (D)
LHS_: D04.T2, D05.A1 (IN), D05.B1 (IN2), D05.C1 (IN3), D05.D1 (IN4)
LH_TO_HS: D11.L2 (C); also elsewhere on the board
LINE_: C10.P1 (IN1), C10.T2 (IN1); also elsewhere on the board
LINE_HOLD_: C07.J2 (IN1), D09.M1 (IN3), D10.V2 (OUT)
MANUAL_PRESET_: D11.D1 (S), D11.F2 (S); also elsewhere on the board
MB03: C11.P1 (IN1); also elsewhere on the board
MB04_: C11.R1 (IN2); also elsewhere on the board
MB05_: C11.S1 (IN3); also elsewhere on the board
MB06_: C11.T2 (IN1); also elsewhere on the board
MB07_: C11.U2 (IN2); also elsewhere on the board
MB08_: C11.V2 (IN3); also elsewhere on the board
MB09: C11.L1 (IN2); also elsewhere on the board
MB10: D10.D1 (IN4), D10.F2 (IN3); also elsewhere on the board
MB11: D10.R1 (IN4), D10.U2 (IN4); also elsewhere on the board
MB11_: D09.F2 (IN3), D10.H2 (IN4); also elsewhere on the board
MEM00: C09.A1 (IN1); also elsewhere on the board
MEM09: D09.C1 (IN3); also elsewhere on the board
MEM_DONE_: C07.T2 (IN3); also elsewhere on the board
MEM_INH9_11_: C09.K2 (OUT), D10.J1 (IN3); also elsewhere on the board
MEM_TO_LSR_: C08.P2 (IN2); also elsewhere on the board
unnamed: D07.A1 (IN1), D07.D1 (IN1), D07.F2 (OUT)
unnamed: C09.L1 (IN1), D09.D1 (OUT)
unnamed: C09.J2 (IN2), C09.N1 (OUT)
unnamed: C09.C1 (OUT), C09.D1 (IN1), C11.K2 (IN2)
unnamed: C09.F1 (OUT), C09.H2 (IN1), D10.H1 (IN2)
unnamed: C11.D2 (IN1), C11.J1 (OUT)
unnamed: C10.A1 (IN1), C11.D1 (OUT)
unnamed: D09.T2 (IN1), D09.U1 (OUT)
unnamed: C10.K1 (OUT), D09.E1 (IN1), D10.L2 (IN2)
unnamed: C10.H1 (IN1), C11.U1 (OUT)
unnamed: C10.J2 (IN2), C11.V1 (OUT)
unnamed: C10.K2 (OUT), D10.M2 (IN3)
unnamed: C10.R2 (IN2), C10.V2 (OUT)
unnamed: C10.L2 (IN1), C10.S1 (OUT)
unnamed: C10.M2 (IN2), C10.S2 (OUT)
R0: C09.L2 (IN1), D05.J2 (OUT), D10.R2 (IN1)
R0_: C09.N2 (OUT), D10.M1 (IN1)
S: C07.U2 (IN2), C10.R1 (IN2), C11.L2 (IN3), C11.P2 (IN2), D09.A1 (IN1), D10.D2 (IN1), D10.K1 (IN4), D11.F1 (0); also elsewhere on the board
STORE_: D07.D2 (IN1), D09.P1 (IN1), D10.S1 (OUT); also elsewhere on the board
S_: D09.R2 (IN3), D11.E1 (1); also elsewhere on the board
S_SET_: C11.C1 (IN3), D10.E1 (OUT), D11.C1 (D)
TP3: C08.J2 (IN2), D09.U2 (IN2); also elsewhere on the board
TP4: D11.B1 (C), D11.D2 (C); also elsewhere on the board
TS1: C07.V2 (IN1); also elsewhere on the board
TS2: C11.H1 (IN3), C11.J2 (IN1), D09.B1 (IN2), D10.F1 (IN1); also elsewhere on the board
TS3: C11.K1 (IN1), C11.N2 (IN1), D09.D2 (IN1), D10.P1 (IN3), D10.T2 (IN3); also elsewhere on the board
TT_AC_LOAD_: D09.V1 (OUT); also elsewhere on the board
TT_CARRY_INSERT: C09.P1 (IN1), D09.N1 (OUT); also elsewhere on the board
TT_CARRY_INSERT_: C09.S1 (OUT); also elsewhere on the board
TT_CARRY_INSERT_C_: D09.H2 (OUT), D09.K1 (IN1)
TT_CARRY_INSERT_S: C09.S2 (OUT); also elsewhere on the board
TT_CARRY_INSERT_S_: C09.P2 (IN1), C11.S2 (OUT), D09.L1 (IN2)
TT_CYCLE_: C10.N1 (OUT); also elsewhere on the board
TT_DATA: C10.N2 (OUT); also elsewhere on the board
TT_INCREMENT_: D10.L1 (OUT); also elsewhere on the board
TT_INST: C10.F2 (OUT), C11.M1 (IN3), D10.A1 (IN1)
TT_INST_: C10.E2 (IN2), C10.M1 (IN2), D09.P2 (IN2), D10.P2 (OUT); also elsewhere on the board
TT_IO_ENABLE_: C11.F2 (IN3), C11.N1 (OUT), D09.S1 (IN3); also elsewhere on the board
TT_LINE_SHIFT_: C09.D2 (IN1), C11.M2 (OUT); also elsewhere on the board
TT_L_DISABLE: C10.L1 (IN1), D09.S2 (OUT); also elsewhere on the board
TT_RIGHT_SHIFT_ENABLE: C10.E1 (IN2), C11.H2 (OUT)
TT_RIGHT_SHIFT_ENABLE_: C09.E2 (IN2), C10.F1 (OUT); also elsewhere on the board
TT_SET_: C10.C1 (OUT); also elsewhere on the board
TT_SHIFT_ENABLE: C09.F2 (OUT), C09.H1 (IN1); also elsewhere on the board
TT_SHIFT_ENABLE_: C09.K1 (OUT); also elsewhere on the board
VCC: C07.A2 (VCC), C08.A2 (VCC), C09.A2 (VCC), C10.A2 (VCC), C11.A2 (VCC), D05.A2 (VCC), D07.A2 (VCC), D09.A2 (VCC), D10.A2 (VCC), D11.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-dl8i-0-2 Data Line Interface

Schematic: pdp8i-cpu.sch, sheet 30

Parts:
A09, A10: M162; H807
B07: M115; H807
B09: M113; H807
B11: M216; H807
H05: W011; H807

Connections:
+3V(05): A10.D1 (8B); also elsewhere on the board
+3V(06): B09.H2 (IN1), B09.R1 (IN2), B09.U1; also elsewhere on the board
+3V(07): B07.F1 (IN2), B07.K1 (IN1), B07.P2 (IN2), B07.R2 (IN3), B09.J1 (IN2), B09.M2 (IN2), B09.V1, B11.K2 (R)
CLR_PARITY_ERROR_: B07.S2 (OUT), B11.N2 (S)
GND: A09.C2 (GND), A09.T1 (GND), A10.C2 (GND), A10.J1 (8A), A10.T1 (GND), B07.C2 (GND), B07.T1 (GND), B09.C2 (GND), B09.T1 (GND), B11.C2 (GND), B11.T1 (GND), H05.C2 (GND), H05.F2 (GND), H05.J2 (GND), H05.L2 (GND), H05.N2 (GND), H05.R2 (GND), H05.U2 (GND); also elsewhere on the board
INITIALIZE_: B07.L1 (IN2); also elsewhere on the board
IOP1: B07.K2 (IN2); also elsewhere on the board
IOP4: B07.E1 (IN1); also elsewhere on the board
MB00: A09.E1 (1A); also elsewhere on the board
MB00_: A09.A1 (1B); also elsewhere on the board
MB01: A09.F1 (2A); also elsewhere on the board
MB01_: A09.B1 (2B); also elsewhere on the board
MB02: A09.H1 (4A); also elsewhere on the board
MB02_: A09.C1 (4B); also elsewhere on the board
MB03: A09.J1 (8A); also elsewhere on the board
MB03_: A09.D1 (8B), B07.A1 (IN1); also elsewhere on the board
MB04: A10.P2 (1A); also elsewhere on the board
MB04_: A10.K2 (1B), B07.B1 (IN2); also elsewhere on the board
MB05: A10.R2 (2A), B07.C1 (IN3); also elsewhere on the board
MB05_: A10.L2 (2B); also elsewhere on the board
MB06: A10.S2 (4A); also elsewhere on the board
MB06_: A10.M2 (4B), B07.D2 (IN1); also elsewhere on the board
MB07: A10.T2 (8A); also elsewhere on the board
MB07_: A10.N2 (8B), B07.E2 (IN2); also elsewhere on the board
MB08: A09.P2 (1A); also elsewhere on the board
MB08_: A09.K2 (1B), B07.F2 (IN3); also elsewhere on the board
MB09: A09.R2 (2A); also elsewhere on the board
MB09_: A09.L2 (2B); also elsewhere on the board
MB10: A09.S2 (4A); also elsewhere on the board
MB10_: A09.M2 (4B); also elsewhere on the board
MB11: A09.T2 (8A); also elsewhere on the board
MB11_: A09.N2 (8B); also elsewhere on the board
MB_PARITY_ODD: A10.K1 (ODD), H05.T2
MEM_PARITY_EVEN_: B09.P1 (IN1); also elsewhere on the board
MP_INT_: B07.L2 (IN3), B11.P2 (1); also elsewhere on the board
MP_SKIP_: B07.M2 (OUT); also elsewhere on the board
unnamed: B09.S1 (OUT), B11.M2 (D)
unnamed: A09.L1 (EVEN), A10.A1 (1B)
unnamed: A09.K1 (ODD), A10.E1 (1A)
unnamed: A10.B1 (2B), A10.V2 (EVEN)
unnamed: A10.F1 (2A), A10.U2 (ODD)
unnamed: A09.V2 (EVEN), A10.C1 (4B)
unnamed: A09.U2 (ODD), A10.H1 (4A)
unnamed: B07.D1 (OUT), B09.H1 (IN1)
unnamed: B07.H2 (OUT), B09.J2 (IN2)
unnamed: B09.K1 (OUT), B09.L1 (IN1)
unnamed: B09.K2 (OUT), B09.M1 (IN2)
unnamed: B07.H1 (IN3), B07.J2 (IN1), B09.N2 (OUT)
unnamed: B09.L2 (IN1), B09.N1 (OUT)
unnamed: B07.J1 (OUT), B07.M1 (IN3)
unnamed: B07.N1 (OUT), B07.N2 (IN1)
TP3: B11.L2 (C); also elsewhere on the board
VCC: A09.A2 (VCC), A10.A2 (VCC), B07.A2 (VCC), B09.A2 (VCC), B11.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mp8i-0-1 Memory Parity Option (1/2)
VRS -- substituted latch for cross-coupled gates

Schematic: pdp8i-cpu.sch, sheet 31

Parts:
A07, A08: M162; H807
B08, B09: M113; H807

Connections:
+3V(05): B08.B1 (IN2), B08.E1 (IN2), B08.E2 (IN2), B08.J1 (IN2), B08.J2 (IN2), B08.M1 (IN2), B08.M2 (IN2), B08.U1; also elsewhere on the board
+3V(06): B08.R1 (IN2), B08.R2 (IN2), B08.U2 (IN2), B09.B1 (IN2), B09.D2 (IN1), B09.E1 (IN2); also elsewhere on the board
GND: A07.C2 (GND), A07.T1 (GND), A08.C2 (GND), A08.T1 (GND), B08.C2 (GND), B08.T1 (GND), B09.C2 (GND), B09.T1 (GND); also elsewhere on the board
MEM00: A07.E1 (1A), B08.H1 (IN1); also elsewhere on the board
MEM01: A07.F1 (2A), B08.D2 (IN1); also elsewhere on the board
MEM02: A07.H1 (4A), B08.D1 (IN1); also elsewhere on the board
MEM03: A07.J1 (8A), B08.A1 (IN1); also elsewhere on the board
MEM04: A08.P2 (1A), B08.P1 (IN1); also elsewhere on the board
MEM05: A08.R2 (2A), B08.L2 (IN1); also elsewhere on the board
MEM06: A08.S2 (4A), B08.L1 (IN1); also elsewhere on the board
MEM07: A08.T2 (8A), B08.H2 (IN1); also elsewhere on the board
MEM08: A07.P2 (1A), B09.D1 (IN1); also elsewhere on the board
MEM09: A07.R2 (2A), B09.A1 (IN1); also elsewhere on the board
MEM10: A07.S2 (4A), B08.T2 (IN1); also elsewhere on the board
MEM11: A07.T2 (8A), B08.P2 (IN1); also elsewhere on the board
MEM_P: A08.J1 (8A), B08.V1, B09.E2 (IN2); also elsewhere on the board
MEM_PARITY_EVEN_: A08.L1 (EVEN); also elsewhere on the board
unnamed: A07.L1 (EVEN), A08.A1 (1B)
unnamed: A07.K1 (ODD), A08.E1 (1A)
unnamed: A08.B1 (2B), A08.V2 (EVEN)
unnamed: A08.F1 (2A), A08.U2 (ODD)
unnamed: A07.V2 (EVEN), A08.C1 (4B)
unnamed: A07.U2 (ODD), A08.H1 (4A)
unnamed: A08.M2 (4B), B08.N1 (OUT)
unnamed: A08.L2 (2B), B08.N2 (OUT)
unnamed: A08.K2 (1B), B08.S1 (OUT)
unnamed: A08.N2 (8B), B08.K2 (OUT)
unnamed: A07.M2 (4B), B08.V2 (OUT)
unnamed: A07.B1 (2B), B08.F2 (OUT)
unnamed: A07.C1 (4B), B08.F1 (OUT)
unnamed: A07.D1 (8B), B08.C1 (OUT)
unnamed: A07.A1 (1B), B08.K1 (OUT)
unnamed: A07.L2 (2B), B09.C1 (OUT)
unnamed: A07.K2 (1B), B09.F1 (OUT)
unnamed: A07.N2 (8B), B08.S2 (OUT)
unnamed: A08.D1 (8B), B09.F2 (OUT)
VCC: A07.A2 (VCC), A08.A2 (VCC), B08.A2 (VCC), B09.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mp8i-0-1 Memory Parity Option (2/2)

Schematic: pdp8i-cpu.sch, sheet 32

Parts:
A04: M703; H807

Connections:
GND: A04.C2 (GND), A04.T1 (GND); also elsewhere on the board
INITIALIZE_: A04.S2; also elsewhere on the board
IOP2: A04.M2; also elsewhere on the board
MB03_: A04.D2; also elsewhere on the board
MB04_: A04.E2; also elsewhere on the board
MB05: A04.F2; also elsewhere on the board
MB06_: A04.H2; also elsewhere on the board
MB07_: A04.J2; also elsewhere on the board
MB08_: A04.K2; also elsewhere on the board
PWR_LOW_: A04.R2; also elsewhere on the board
PWR_SKIP_: A04.L2; also elsewhere on the board
RESTART: A04.N2; also elsewhere on the board
RESTART_: A04.U1; also elsewhere on the board
SHUT_DOWN_: A04.U2; also elsewhere on the board
STOP_OK: A04.P2; also elsewhere on the board
VCC: A04.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-kp8i-0-1 Power Fail and Restart Option

Schematic: pdp8i-cpu.sch, sheet 33

Notes on the sheet:
D-BS-vc8i-0-1 Display Control

Schematic: pdp8i-cpu.sch, sheet 34

Notes on the sheet:
D-BS-vp8i-0-1 Plotter Control

Schematic: pdp8i-cpu.sch, sheet 35

Notes on the sheet:
D-BS-pp8i-0-1 High Speed Punch

Schematic: pdp8i-cpu.sch, sheet 36

Notes on the sheet:
D-BS-pr8i-0-1 High Speed Reader

Schematic: pdp8i-cpu.sch, sheet 37

Notes on the sheet:
D-BS-kw8i-0-1 Real Time Clock Option

Schematic: pdp8i-cpu.sch, sheet 38

Notes on the sheet:
D-BS-cr8i-0-2 Card Reader Control #1

Schematic: pdp8i-cpu.sch, sheet 39

Notes on the sheet:
D-BS-cr8i-0-3 Card Reader Control #2

Board: 2 copper layers, 243 parts (0 on the bottom side), 1227 nets, no tracks yet.

Other parts of the board:
U$1, U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9, U$10, U$11, U$12, U$13, U$14, U$15, U$16, U$17, U$18, U$19, U$20, U$21, U$22, U$23, U$24, U$25, U$26, U$27, U$28, U$29, U$30, U$31, U$32, U$33, U$34, U$35, U$36, U$37, U$38, U$39, U$40: CBLOCK
