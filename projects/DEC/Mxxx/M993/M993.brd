# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8I/pdp8i-cpu.brd (continued)

Schematic: pdp8i-cpu.sch, sheet 13

Parts:
B40: W077; H807
E24: M113; H807
E25: M115; H807
EF38, EF39: M220; H807-2

Connections:
ACBAR_ENABLE: EF39.BJ2; also elsewhere on the board
AC_ENABLE: EF39.BH2; also elsewhere on the board
ADDER00: EF39.AJ2; also elsewhere on the board
ADDER08: EF39.AB1; also elsewhere on the board
ADDER09: EF39.AC1; also elsewhere on the board
ADDER10: EF39.AE2, EF39.BB2; also elsewhere on the board
ADDER11: EF39.AF1; also elsewhere on the board
ADDER_L_: E24.B1 (IN2); also elsewhere on the board
AND_ENABLE: EF39.AA1; also elsewhere on the board
CARRY_INSERT_: EF39.BJ1; also elsewhere on the board
DATA09: EF38.BP2; also elsewhere on the board
DATA10: EF39.BM2; also elsewhere on the board
DATA11: EF39.BP2; also elsewhere on the board
DATA_ADD09: EF38.BU1; also elsewhere on the board
DATA_ADD10: EF39.BS1; also elsewhere on the board
DATA_ADD11: EF39.BU1; also elsewhere on the board
DATA_ADD_ENABLE: EF39.BT2; also elsewhere on the board
DATA_ENABLE: EF39.BL1; also elsewhere on the board
DOUBLE_LEFT_ROTATE: EF39.AH1; also elsewhere on the board
DOUBLE_RIGHT_ROTATE: EF39.AD1; also elsewhere on the board
E25D1: E25.D1 (OUT), EF39.AH2
EAE_MQ0BAR_ENABLE_: E25.B1 (IN2); also elsewhere on the board
EAE_MQ0_ENABLE_: E25.C1 (IN3); also elsewhere on the board
EAE_ON_: E24.A1 (IN1); also elsewhere on the board
GND: E24.C2 (GND), E24.T1 (GND), E25.C2 (GND), E25.T1 (GND), EF38.AC2 (GND), EF38.AT1 (GND), EF38.BC2 (GND), EF38.BE2, EF38.BT1 (GND), EF39.AC2 (GND), EF39.AT1 (GND), EF39.BC2 (GND), EF39.BT1 (GND); also elsewhere on the board
INPUT_BUS09: EF38.BM1; also elsewhere on the board
INPUT_BUS10: EF39.BK1; also elsewhere on the board
INPUT_BUS11: EF39.BM1; also elsewhere on the board
IO_ENABLE: EF39.BL2; also elsewhere on the board
LEFT_SHIFT: EF39.AF2; also elsewhere on the board
MA_ENABLE5_11: EF38.BR2, EF39.BP1, EF39.BR2; also elsewhere on the board
MEM09: EF38.BV2; also elsewhere on the board
MEM10: EF39.BR1; also elsewhere on the board
MEM11: EF39.BV2; also elsewhere on the board
MEM_ENABLE9_11: EF38.BV1, EF39.BU2, EF39.BV1; also elsewhere on the board
MQ09: EF38.BN2; also elsewhere on the board
MQ10: EF39.BH1; also elsewhere on the board
MQ11: EF39.BN2; also elsewhere on the board
MQ_ENABLE: EF39.BF1; also elsewhere on the board
unnamed: EF38.BJ1, EF39.BK2
unnamed: E24.C1 (OUT), E25.A1 (IN1)
NO_SHIFT: EF39.AE1; also elsewhere on the board
PC_ENABLE: EF39.BS2; also elsewhere on the board
RIGHT_SHIFT: EF39.AD2; also elsewhere on the board
SC2: EF38.BN1; also elsewhere on the board
SC3: EF39.BD1; also elsewhere on the board
SC4: EF39.BN1; also elsewhere on the board
SC_ENABLE: EF39.BF2; also elsewhere on the board
SR09: B40.F2, EF38.BD2
SR10: B40.H2, EF39.BE1
SR11: B40.J2, EF39.BD2
SR_ENABLE: EF39.BC1; also elsewhere on the board
TT_CARRY_INSERT_S: EF39.BE2; also elsewhere on the board
TT_LINE_SHIFT_: EF39.AB2; also elsewhere on the board
VCC: E24.A2 (VCC), E25.A2 (VCC), EF38.AA2 (VCC), EF38.BA2 (VCC), EF39.AA2 (VCC), EF39.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-9 Major Registers Gating (4/4)
REG_BUS09
REG_BUS10
REG_BUS11

Schematic: pdp8i-cpu.sch, sheet 14

Parts:
H07, H08, H09, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20: M650; H807
J01, J02, J03, J04, J05, J06, J07, J08, J09, J10, J11: W011; H807
J13, J14, J15, J16, J17, J18, J19, J20: M506; H807

Connections:
3CYCLE: J10.K2, J20.D2 (IN)
3_CYCLE: J20.J2 (OUT); also elsewhere on the board
+3V(49): H07.F2 (IN1), H07.J2 (IN3), H07.M2 (IN1), H07.P2 (IN3), H07.T2 (IN1), H07.V2 (IN3), H08.F2 (IN1), H08.J2 (IN3), H08.M2 (IN1), H08.P2 (IN3), H08.T2 (IN1), H08.V2 (IN3); also elsewhere on the board
+3V(50): H09.F2 (IN1), H09.J2 (IN3), H09.M2 (IN1), H09.P2 (IN3), H09.T2 (IN1), H09.V2 (IN3), H10.F2 (IN1), H10.J2 (IN3), H10.M2 (IN1), H10.P2 (IN3), H10.T2 (IN1), H10.V2 (IN3); also elsewhere on the board
+3V(51): H11.F2 (IN1), H11.J2 (IN3), H11.M2 (IN1), H11.P2 (IN3), H11.T2 (IN1), H11.V2 (IN3), H12.F2 (IN1), H12.J2 (IN3), H12.M2 (IN1), H12.P2 (IN3), H12.T2 (IN1), H12.V2 (IN3); also elsewhere on the board
+3V(52): H13.F2 (IN1), H13.J2 (IN3), H13.M2 (IN1), H13.P2 (IN3), H13.T2 (IN1), H13.V2 (IN3), H14.F2 (IN1), H14.J2 (IN3), H14.M2 (IN1), H14.P2 (IN3), H14.T2 (IN1), H14.V2 (IN3); also elsewhere on the board
+3V(53): H15.F2 (IN1), H15.J2 (IN3), H15.M2 (IN1), H15.P2 (IN3), H15.T2 (IN1), H15.V2 (IN3), H16.F2 (IN1), H16.J2 (IN3), H16.M2 (IN1), H16.P2 (IN3), H16.T2 (IN1), H16.V2 (IN3); also elsewhere on the board
+3V(54): H17.F2 (IN1), H17.J2 (IN3), H17.M2 (IN1), H17.P2 (IN3), H17.T2 (IN1), H17.V2 (IN3), H18.F2 (IN1), H18.J2 (IN3), H18.M2 (IN1), H18.P2 (IN3), H18.T2 (IN1), H18.V2 (IN3); also elsewhere on the board
+3V(55): H19.F2 (IN1), H19.J2 (IN3), H19.M2 (IN1), H19.P2 (IN3), H19.T2 (IN1), H19.V2 (IN3), H20.F2 (IN1), H20.J2 (IN3), H20.M2 (IN1), H20.P2 (IN3); also elsewhere on the board
-15V: H07.B2 (-15V), H08.B2 (-15V), H09.B2 (-15V), H10.B2 (-15V), H11.B2 (-15V), H12.B2 (-15V), H13.B2 (-15V), H14.B2 (-15V), H15.B2 (-15V), H16.B2 (-15V), H17.B2 (-15V), H18.B2 (-15V), H19.B2 (-15V), H20.B2 (-15V), J13.B2 (-15V), J14.B2 (-15V), J15.B2 (-15V), J16.B2 (-15V), J17.B2 (-15V), J18.B2 (-15V), J19.B2 (-15V), J20.B2 (-15V); also elsewhere on the board
AC00: H07.H2 (IN2); also elsewhere on the board
AC01: H07.N2 (IN2); also elsewhere on the board
AC02: H07.U2 (IN2); also elsewhere on the board
AC03: H08.H2 (IN2); also elsewhere on the board
AC04: H08.N2 (IN2); also elsewhere on the board
AC05: H08.U2 (IN2); also elsewhere on the board
AC06: H09.H2 (IN2); also elsewhere on the board
AC07: H09.N2 (IN2); also elsewhere on the board
AC08: H09.U2 (IN2); also elsewhere on the board
AC09: H10.H2 (IN2); also elsewhere on the board
AC10: H10.N2 (IN2); also elsewhere on the board
AC11: H10.U2 (IN2); also elsewhere on the board
ACCLR: J06.P2, J15.F1 (IN)
AC_CLEAR: J15.L1 (OUT); also elsewhere on the board
ADD_ACCEPTED_: H20.N2 (IN2); also elsewhere on the board
BAC00: H07.D2 (OUT), J01.D2
BAC01: H07.K2 (OUT), J01.E2
BAC02: H07.S2 (OUT), J01.H2
BAC03: H08.D2 (OUT), J01.K2
BAC04: H08.K2 (OUT), J01.M2
BAC05: H08.S2 (OUT), J01.P2
BAC06: H09.D2 (OUT), J01.S2
BAC07: H09.K2 (OUT), J01.T2
BAC08: H09.S2 (OUT), J01.V2
BAC09: H10.D2 (OUT), J02.D2
BAC10: H10.K2 (OUT), J02.E2
BAC11: H10.S2 (OUT), J02.H2
BADD_ACCEPTED_: H20.K2 (OUT), J08.S2
BBREAK: H20.D2 (OUT), J08.P2
BINITIALIZE_: H12.S2 (OUT), J02.V2
BIOP1_: H11.D2 (OUT), J02.K2
BIOP2_: H11.K2 (OUT), J02.M2
BIOP4_: H11.S2 (OUT), J02.P2
BMB00: H13.D2 (OUT), J03.D2
BMB01: H13.K2 (OUT), J03.E2
BMB02: H13.S2 (OUT), J03.H2
BMB03: H14.K2 (OUT), J03.M2
BMB03_: H14.D2 (OUT), J03.K2
BMB04: H15.D2 (OUT), J03.S2
BMB04_: H14.S2 (OUT), J03.P2
BMB05: H15.S2 (OUT), J03.V2
BMB05_: H15.K2 (OUT), J03.T2
BMB06: H16.K2 (OUT), J04.E2
BMB06_: H16.D2 (OUT), J04.D2
BMB07: H17.D2 (OUT), J04.K2
BMB07_: H16.S2 (OUT), J04.H2
BMB08: H17.S2 (OUT), J04.P2
BMB08_: H17.K2 (OUT), J04.M2
BMB09: H18.D2 (OUT), J04.S2
BMB10: H18.K2 (OUT), J04.T2
BMB11: H18.S2 (OUT), J04.V2
BREAK_: H20.H2 (IN2); also elsewhere on the board
BRK_RQST: J15.S1 (OUT); also elsewhere on the board
BRQ: J08.K2, J15.M1 (IN)
BRUN_: H19.D2 (OUT), J06.S2
BTS1: H12.K2 (OUT), J02.T2
BTS3: H12.D2 (OUT), J02.S2
BTT_INST_: H19.K2 (OUT), J06.T2
BWC_OVERFLOW: H19.S2 (OUT), J10.P2
CA_INCREMENT_: J20.L1 (OUT); also elsewhere on the board
CA_INCR_: J10.M2, J20.F1 (IN)
D00: J09.D2, J18.A1 (IN)
D01: J09.E2, J18.D2 (IN)
D02: J09.H2, J18.F1 (IN)
D03: J09.K2, J18.K2 (IN)
D04: J09.M2, J18.M1 (IN)
D05: J09.P2, J18.R2 (IN)
D06: J09.S2, J19.A1 (IN)
D07: J09.T2, J19.D2 (IN)
D08: J09.V2, J19.F1 (IN)
D09: J10.D2, J19.K2 (IN)
D10: J10.E2, J19.M1 (IN)
D11: J10.H2, J19.R2 (IN)
DA00: J07.D2, J16.A1 (IN)
DA01: J07.E2, J16.D2 (IN)
DA02: J07.H2, J16.F1 (IN)
DA03: J07.K2, J16.K2 (IN)
DA04: J07.M2, J16.M1 (IN)
DA05: J07.P2, J16.R2 (IN)
DA06: J07.S2, J17.A1 (IN)
DA07: J07.T2, J17.D2 (IN)
DA08: J07.V2, J17.F1 (IN)
DA09: J08.D2, J17.K2 (IN)
DA10: J08.E2, J17.M1 (IN)
DA11: J08.H2, J17.R2 (IN)
DATA00: J18.E1 (OUT); also elsewhere on the board
DATA01: J18.J2 (OUT); also elsewhere on the board
DATA02: J18.L1 (OUT); also elsewhere on the board
DATA03: J18.P2 (OUT); also elsewhere on the board
DATA04: J18.S1 (OUT); also elsewhere on the board
DATA05: J18.V2 (OUT); also elsewhere on the board
DATA06: J19.E1 (OUT); also elsewhere on the board
DATA07: J19.J2 (OUT); also elsewhere on the board
DATA08: J19.L1 (OUT); also elsewhere on the board
DATA09: J19.P2 (OUT); also elsewhere on the board
DATA10: J19.S1 (OUT); also elsewhere on the board
DATA11: J19.V2 (OUT); also elsewhere on the board
DATA_ADD00: J16.E1 (OUT); also elsewhere on the board
DATA_ADD01: J16.J2 (OUT); also elsewhere on the board
DATA_ADD02: J16.L1 (OUT); also elsewhere on the board
DATA_ADD03: J16.P2 (OUT); also elsewhere on the board
DATA_ADD04: J16.S1 (OUT); also elsewhere on the board
DATA_ADD05: J16.V2 (OUT); also elsewhere on the board
DATA_ADD06: J17.E1 (OUT); also elsewhere on the board
DATA_ADD07: J17.J2 (OUT); also elsewhere on the board
DATA_ADD08: J17.L1 (OUT); also elsewhere on the board
DATA_ADD09: J17.P2 (OUT); also elsewhere on the board
DATA_ADD10: J17.S1 (OUT); also elsewhere on the board
DATA_ADD11: J17.V2 (OUT); also elsewhere on the board
DATA_IN_: J15.V2 (OUT); also elsewhere on the board
D_IN_: J08.M2, J15.R2 (IN)
EDA0: J10.V2, J11.H2, J20.K2 (IN)
EDA1: J10.T2, J11.E2, J20.M1 (IN)
EDA2: J10.S2, J11.D2, J20.R2 (IN)
EXT_DATA_ADD0: J20.P2 (OUT); also elsewhere on the board
EXT_DATA_ADD1: J20.S1 (OUT); also elsewhere on the board
EXT_DATA_ADD2: J20.V2 (OUT); also elsewhere on the board
GND: H07.C2 (GND), H07.E2 (SLOW), H07.L2 (SLOW), H07.R2 (SLOW), H08.C2 (GND), H08.E2 (SLOW), H08.L2 (SLOW), H08.R2 (SLOW), H09.C2 (GND), H09.E2 (SLOW), H09.L2 (SLOW), H09.R2 (SLOW), H10.C2 (GND), H10.E2 (SLOW), H10.L2 (SLOW), H10.R2 (SLOW), H11.C2 (GND), H11.E2 (SLOW), H11.L2 (SLOW), H11.R2 (SLOW), H12.C2 (GND), H12.E2 (SLOW), H12.L2 (SLOW), H12.R2 (SLOW), H13.C2 (GND), H13.E2 (SLOW), H13.L2 (SLOW), H13.R2 (SLOW), H14.C2 (GND), H14.E2 (SLOW), H14.L2 (SLOW), H14.R2 (SLOW), H15.C2 (GND), H15.E2 (SLOW), H15.L2 (SLOW), H15.R2 (SLOW), H16.C2 (GND), H16.E2 (SLOW), H16.L2 (SLOW), H16.R2 (SLOW), H17.C2 (GND), H17.E2 (SLOW), H17.L2 (SLOW), H17.R2 (SLOW), H18.C2 (GND), H18.E2 (SLOW), H18.L2 (SLOW), H18.R2 (SLOW), H19.C2 (GND), H19.E2 (SLOW), H19.L2 (SLOW), H19.R2 (SLOW), H20.C2 (GND), H20.E2 (SLOW), H20.L2 (SLOW), J01.C2 (GND), J01.F2 (GND), J01.J2 (GND), J01.L2 (GND), J01.N2 (GND), J01.R2 (GND), J01.U2 (GND), J02.C2 (GND), J02.F2 (GND), J02.J2 (GND), J02.L2 (GND), J02.N2 (GND), J02.R2 (GND), J02.U2 (GND), J03.C2 (GND), J03.F2 (GND), J03.J2 (GND), J03.L2 (GND), J03.N2 (GND), J03.R2 (GND), J03.U2 (GND), J04.C2 (GND), J04.F2 (GND), J04.J2 (GND), J04.L2 (GND), J04.N2 (GND), J04.R2 (GND), J04.U2 (GND), J05.C2 (GND), J05.F2 (GND), J05.J2 (GND), J05.L2 (GND), J05.N2 (GND), J05.R2 (GND), J05.U2 (GND), J06.C2 (GND), J06.F2 (GND), J06.J2 (GND), J06.L2 (GND), J06.N2 (GND), J06.R2 (GND), J06.U2 (GND), J07.C2 (GND), J07.F2 (GND), J07.J2 (GND), J07.L2 (GND), J07.N2 (GND), J07.R2 (GND), J07.U2 (GND), J08.C2 (GND), J08.F2 (GND), J08.J2 (GND), J08.L2 (GND), J08.N2 (GND), J08.R2 (GND), J08.U2 (GND), J09.C2 (GND), J09.F2 (GND), J09.J2 (GND), J09.L2 (GND), J09.N2 (GND), J09.R2 (GND), J09.U2 (GND), J10.C2 (GND), J10.F2 (GND), J10.J2 (GND), J10.L2 (GND), J10.N2 (GND), J10.R2 (GND), J10.U2 (GND), J11.C2 (GND), J11.F2 (GND), J11.J2 (GND), J11.L2 (GND), J11.N2 (GND), J11.R2 (GND), J11.U2 (GND), J13.C2 (GND), J13.T1 (GND), J14.C2 (GND), J14.T1 (GND), J15.C2 (GND), J15.T1 (GND), J16.C2 (GND), J16.T1 (GND), J17.C2 (GND), J17.T1 (GND), J18.C2 (GND), J18.T1 (GND), J19.C2 (GND), J19.T1 (GND), J20.C2 (GND), J20.T1 (GND); also elsewhere on the board
IN00: J05.D2, J13.A1 (IN)
IN01: J05.E2, J13.D2 (IN)
IN02: J05.H2, J13.F1 (IN)
IN03: J05.K2, J13.K2 (IN)
IN04: J05.M2, J13.M1 (IN)
IN05: J05.P2, J13.R2 (IN)
IN06: J05.S2, J14.A1 (IN)
IN07: J05.T2, J14.D2 (IN)
IN08: J05.V2, J14.F1 (IN)
IN09: J06.D2, J14.K2 (IN)
IN10: J06.E2, J14.M1 (IN)
IN11: J06.H2, J14.R2 (IN)
INITIALIZE_: H12.U2 (IN2); also elsewhere on the board
INPUT_BUS00: J13.E1 (OUT); also elsewhere on the board
INPUT_BUS01: J13.J2 (OUT); also elsewhere on the board
INPUT_BUS02: J13.L1 (OUT); also elsewhere on the board
INPUT_BUS03: J13.P2 (OUT); also elsewhere on the board
INPUT_BUS04: J13.S1 (OUT); also elsewhere on the board
INPUT_BUS05: J13.V2 (OUT); also elsewhere on the board
INPUT_BUS06: J14.E1 (OUT); also elsewhere on the board
INPUT_BUS07: J14.J2 (OUT); also elsewhere on the board
INPUT_BUS08: J14.L1 (OUT); also elsewhere on the board
INPUT_BUS09: J14.P2 (OUT); also elsewhere on the board
INPUT_BUS10: J14.S1 (OUT); also elsewhere on the board
INPUT_BUS11: J14.V2 (OUT); also elsewhere on the board
INT_RQST: J15.J2 (OUT); also elsewhere on the board
IOP1_: H11.H2 (IN2); also elsewhere on the board
IOP2_: H11.N2 (IN2); also elsewhere on the board
IOP4_: H11.U2 (IN2); also elsewhere on the board
IO_SKIP: J15.E1 (OUT); also elsewhere on the board
IRQ: J06.M2, J15.D2 (IN)
LINE_: J15.P2 (OUT); also elsewhere on the board
LINE_IN: J06.V2, J15.K2 (IN)
MB00: H13.H2 (IN2); also elsewhere on the board
MB01: H13.N2 (IN2); also elsewhere on the board
MB02: H13.U2 (IN2); also elsewhere on the board
MB03: H14.N2 (IN2); also elsewhere on the board
MB03_: H14.H2 (IN2); also elsewhere on the board
MB04: H15.H2 (IN2); also elsewhere on the board
MB04_: H14.U2 (IN2); also elsewhere on the board
MB05: H15.U2 (IN2); also elsewhere on the board
MB05_: H15.N2 (IN2); also elsewhere on the board
MB06: H16.N2 (IN2); also elsewhere on the board
MB06_: H16.H2 (IN2); also elsewhere on the board
MB07: H17.H2 (IN2); also elsewhere on the board
MB07_: H16.U2 (IN2); also elsewhere on the board
MB08: H17.U2 (IN2); also elsewhere on the board
MB08_: H17.N2 (IN2); also elsewhere on the board
MB09: H18.H2 (IN2); also elsewhere on the board
MB10: H18.N2 (IN2); also elsewhere on the board
MB11: H18.U2 (IN2); also elsewhere on the board
ME05_: J13.U2 (IN4); also elsewhere on the board
ME06_: J14.D1 (IN4); also elsewhere on the board
ME07_: J14.H2 (IN4); also elsewhere on the board
ME08_: J14.K1 (IN4); also elsewhere on the board
ME09_: J14.N2 (IN4); also elsewhere on the board
ME10_: J14.R1 (IN4); also elsewhere on the board
ME11_: J14.U2 (IN4); also elsewhere on the board
MEMORY_INCREMENT: J20.E1 (OUT); also elsewhere on the board
MEM_INCR: J08.T2, J20.A1 (IN)
MP_INT_: J15.H2 (IN4); also elsewhere on the board
MP_SKIP_: J15.D1 (IN4); also elsewhere on the board
unnamed: J14.S2 (IN2), J14.T2 (IN3)
unnamed: J14.N1 (IN2), J14.P1 (IN3)
unnamed: J14.L2 (IN2), J14.M2 (IN3)
unnamed: J14.H1 (IN2), J14.J1 (IN3)
unnamed: J14.E2 (IN2), J14.F2 (IN3)
unnamed: J14.B1 (IN2), J14.C1 (IN3)
unnamed: J13.S2 (IN2), J13.T2 (IN3)
unnamed: J13.N1 (IN2), J13.P1 (IN3), J13.R1 (IN4)
unnamed: J13.L2 (IN2), J13.M2 (IN3), J13.N2 (IN4)
unnamed: J13.H1 (IN2), J13.J1 (IN3), J13.K1 (IN4)
unnamed: J13.E2 (IN2), J13.F2 (IN3), J13.H2 (IN4)
unnamed: J15.H1 (IN2), J15.J1 (IN3), J15.K1 (IN4)
unnamed: J13.B1 (IN2), J13.C1 (IN3), J13.D1 (IN4)
unnamed: J16.E2 (IN2), J16.F2 (IN3), J16.H2 (IN4)
unnamed: J16.N1 (IN2), J16.P1 (IN3), J16.R1 (IN4)
unnamed: J16.B1 (IN2), J16.C1 (IN3), J16.D1 (IN4)
unnamed: J16.H1 (IN2), J16.J1 (IN3), J16.K1 (IN4)
unnamed: J16.L2 (IN2), J16.M2 (IN3), J16.N2 (IN4)
unnamed: J16.S2 (IN2), J16.T2 (IN3), J16.U2 (IN4)
unnamed: J17.N1 (IN2), J17.P1 (IN3), J17.R1 (IN4)
unnamed: J17.B1 (IN2), J17.C1 (IN3), J17.D1 (IN4)
unnamed: J17.E2 (IN2), J17.F2 (IN3), J17.H2 (IN4)
unnamed: J17.H1 (IN2), J17.J1 (IN3), J17.K1 (IN4)
unnamed: J17.L2 (IN2), J17.M2 (IN3), J17.N2 (IN4)
unnamed: J17.S2 (IN2), J17.T2 (IN3), J17.U2 (IN4)
unnamed: J19.S2 (IN2), J19.T2 (IN3), J19.U2 (IN4)
unnamed: J19.N1 (IN2), J19.P1 (IN3), J19.R1 (IN4)
unnamed: J19.L2 (IN2), J19.M2 (IN3), J19.N2 (IN4)
unnamed: J19.H1 (IN2), J19.J1 (IN3), J19.K1 (IN4)
unnamed: J19.E2 (IN2), J19.F2 (IN3), J19.H2 (IN4)
unnamed: J19.B1 (IN2), J19.C1 (IN3), J19.D1 (IN4)
unnamed: J18.S2 (IN2), J18.T2 (IN3), J18.U2 (IN4)
unnamed: J18.N1 (IN2), J18.P1 (IN3), J18.R1 (IN4)
unnamed: J18.L2 (IN2), J18.M2 (IN3), J18.N2 (IN4)
unnamed: J18.H1 (IN2), J18.J1 (IN3), J18.K1 (IN4)
unnamed: J18.E2 (IN2), J18.F2 (IN3), J18.H2 (IN4)
unnamed: J18.B1 (IN2), J18.C1 (IN3), J18.D1 (IN4)
unnamed: J15.L2 (IN2), J15.M2 (IN3), J15.N2 (IN4)
unnamed: J15.S2 (IN2), J15.T2 (IN3), J15.U2 (IN4)
unnamed: J15.N1 (IN2), J15.P1 (IN3), J15.R1 (IN4)
unnamed: J20.B1 (IN2), J20.C1 (IN3), J20.D1 (IN4)
unnamed: J20.E2 (IN2), J20.F2 (IN3), J20.H2 (IN4)
unnamed: J20.H1 (IN2), J20.J1 (IN3), J20.K1 (IN4)
unnamed: J20.N1 (IN2), J20.P1 (IN3), J20.R1 (IN4)
unnamed: J20.L2 (IN2), J20.M2 (IN3), J20.N2 (IN4)
unnamed: J20.S2 (IN2), J20.T2 (IN3), J20.U2 (IN4)
PWR_LOW_: J15.E2 (IN2); also elsewhere on the board
PWR_SKIP_: J15.C1 (IN3); also elsewhere on the board
RUN_: H19.H2 (IN2); also elsewhere on the board
SKIPB: J06.K2, J15.A1 (IN)
TS1_: H12.N2 (IN2); also elsewhere on the board
TS3_: H12.H2 (IN2); also elsewhere on the board
TT_INST_: H19.N2 (IN2); also elsewhere on the board
UINT_: J15.F2 (IN3); also elsewhere on the board
VCC: H07.A2 (VCC), H08.A2 (VCC), H09.A2 (VCC), H10.A2 (VCC), H11.A2 (VCC), H12.A2 (VCC), H13.A2 (VCC), H14.A2 (VCC), H15.A2 (VCC), H16.A2 (VCC), H17.A2 (VCC), H18.A2 (VCC), H19.A2 (VCC), H20.A2 (VCC), J13.A2 (VCC), J14.A2 (VCC), J15.A2 (VCC), J16.A2 (VCC), J17.A2 (VCC), J18.A2 (VCC), J19.A2 (VCC), J20.A2 (VCC); also elsewhere on the board
WC_OVERFLOW_: H19.U2 (IN2); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-10 I/O Level Converter
8i-00009?
1. For ka8i, substitute D-BS-ka8i-0-1 for this print.
2. G717 is always placed at the end of the I/O bus.
(Place G717 in location J02 if no options on the I/O bus.)

Schematic: pdp8i-cpu.sch, sheet 15

Notes on the sheet:
D-BS-8i-0-11 Teletype Receivers

Schematic: pdp8i-cpu.sch, sheet 16

Notes on the sheet:
D-BS-8i-0-12 Teletype Transmitter

Schematic: pdp8i-cpu.sch, sheet 17

Parts:
AB02: G826; H807-2
AB03: G792; H807-2
B21: M113; H807
C12: M617; H807

Connections:
-15V: AB02.AB2 (-15V), AB03.BK2 (-15V), AB03.BL2 (-15V), AB03.BM2 (-15V), AB03.BN2 (-15V), AB03.BP2 (-15V), AB03.BR2 (-15V), AB03.BS2 (-15V), AB03.BT2 (-15V), AB03.BU2 (-15V), AB03.BV2 (-15V); also elsewhere on the board
B_POWER_CLEAR_: C12.S1 (OUT); also elsewhere on the board
GND: AB02.AC2 (GND), AB02.BC2 (GND), AB03.AD1 (GND), AB03.AE1 (GND), AB03.AF1 (GND), AB03.AH1 (GND), AB03.AJ1 (GND), AB03.AK1 (GND), AB03.AL1 (GND), AB03.AM1 (GND), AB03.AN1 (GND), AB03.AP1 (GND), AB03.AR1 (GND), AB03.AS1 (GND), AB03.AT1 (GND), AB03.AU1 (GND), AB03.AV1 (GND), AB03.BD1 (GND), AB03.BE1 (GND), AB03.BF1 (GND), AB03.BH1 (GND), AB03.BJ1 (GND), AB03.BK1 (GND), AB03.BL1 (GND), AB03.BM1 (GND), AB03.BN1 (GND), AB03.BP1 (GND), AB03.BR1 (GND), AB03.BS1 (GND), AB03.BT1 (GND), AB03.BU1 (GND), AB03.BV1 (GND), B21.C2 (GND), B21.T1 (GND), C12.C2 (GND), C12.T1 (GND); also elsewhere on the board
unnamed: B21.V2 (OUT), C12.M1 (IN1), C12.N1 (IN2), C12.P1 (IN3), C12.R1 (IN4)
POWER_CLEAR_: AB02.AS2, B21.T2 (IN1), B21.U2 (IN2)
POWER_OK_: AB02.AJ2; also elsewhere on the board
SHUT_DOWN_: AB02.AF2; also elsewhere on the board
STOP_OK: AB02.AH2; also elsewhere on the board
VCC: AB02.AA2 (VCC), AB02.BA2 (VCC), AB03.AD2 (VCC), AB03.AE2 (VCC), AB03.AF2 (VCC), AB03.AH2 (VCC), AB03.AJ2 (VCC), AB03.AK2 (VCC), AB03.AL2 (VCC), AB03.AM2 (VCC), AB03.AN2 (VCC), AB03.AP2 (VCC), AB03.AR2 (VCC), AB03.AS2 (VCC), AB03.AT2 (VCC), AB03.AU2 (VCC), AB03.AV2 (VCC), AB03.BD2 (VCC), AB03.BE2 (VCC), AB03.BF2 (VCC), AB03.BH2 (VCC), AB03.BJ2 (VCC), B21.A2 (VCC), C12.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-13 Memory Control
Power Cabling:

Schematic: pdp8i-cpu.sch, sheet 18

Parts:
H04, H05: W011; H807

Connections:
GND: H04.C2 (GND), H04.F2 (GND), H04.J2 (GND), H04.L2 (GND), H04.N2 (GND), H04.R2 (GND), H04.U2 (GND), H05.C2 (GND), H05.F2 (GND), H05.J2 (GND), H05.L2 (GND), H05.N2 (GND), H05.R2 (GND), H05.U2 (GND); also elsewhere on the board
MEM00: H04.E2; also elsewhere on the board
MEM01: H04.H2; also elsewhere on the board
MEM02: H04.K2; also elsewhere on the board
MEM03: H04.M2; also elsewhere on the board
MEM04: H04.P2; also elsewhere on the board
MEM05: H04.S2; also elsewhere on the board
MEM06: H04.T2; also elsewhere on the board
MEM07: H04.V2; also elsewhere on the board
MEM08: H05.D2; also elsewhere on the board
MEM09: H05.E2; also elsewhere on the board
MEM10: H05.H2; also elsewhere on the board
MEM11: H05.K2; also elsewhere on the board
MEM_P: H04.D2; also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-14 Sense Amps and Inhibit Drivers

Schematic: pdp8i-cpu.sch, sheet 19

Notes on the sheet:
D-BS-8i-0-15 X Axis Selection

Schematic: pdp8i-cpu.sch, sheet 20

Notes on the sheet:
D-BS-8i-0-16 Y Axis Selection

Schematic: pdp8i-cpu.sch, sheet 21

Parts:
A13, A16, A19: M113; H807
B10: M720; H807
B11, B18, B19: M216; H807
B12, B13, B14, B15, B16: M617; H807
B20: M115; H807
B21: M113; H807
E12: M113; H807
H01, H02, H03: W011; H807

Connections:
+3V(04): A19.D1 (IN1), A19.D2 (IN1), A19.L2 (IN1); also elsewhere on the board
+3V(08): B11.A1 (R), B12.B1 (IN2), B12.C1 (IN3), B12.D1 (IN4), B12.E2 (IN2), B12.F2 (IN3), B12.H1 (IN2), B12.H2 (IN4), B12.J1 (IN3), B12.K1 (IN4); also elsewhere on the board
+3V(09): B12.L2 (IN2), B12.M2 (IN3), B12.N1 (IN2), B12.N2 (IN4), B12.P1 (IN3), B12.R1 (IN4); also elsewhere on the board
+3V(10): B12.S2 (IN2), B12.T2 (IN3), B12.U2 (IN4), B13.B1 (IN2), B13.C1 (IN3), B13.D1 (IN4), B13.E2 (IN2), B13.F2 (IN3), B13.H2 (IN4); also elsewhere on the board
+3V(11): A13.U1, B13.H1 (IN2), B13.J1 (IN3), B13.K1 (IN4)
+3V(12): B13.L2 (IN2), B13.M2 (IN3), B13.N1 (IN2), B13.N2 (IN4), B13.P1 (IN3), B13.R1 (IN4), B13.S2 (IN2), B13.T2 (IN3), B13.U1, B13.U2 (IN4), B14.B1 (IN2), B14.C1 (IN3), B14.D1 (IN4)
+3V(13): B13.V1, B14.E2 (IN2), B14.F2 (IN3), B14.H2 (IN4)
+3V(14): B14.H1 (IN2), B14.J1 (IN3), B14.K1 (IN4), B14.L2 (IN2), B14.M2 (IN3), B14.N1 (IN2), B14.N2 (IN4), B14.P1 (IN3), B14.R1 (IN4), B14.U1
+3V(15): B14.S2 (IN2), B14.T2 (IN3), B14.U2 (IN4), B14.V1, B15.B1 (IN2), B15.C1 (IN3), B15.D1 (IN4)
+3V(16): B15.E2 (IN2), B15.F2 (IN3), B15.H1 (IN2), B15.H2 (IN4), B15.J1 (IN3), B15.K1 (IN4), B15.U1
+3V(17): B15.L2 (IN2), B15.M2 (IN3), B15.N1 (IN2), B15.N2 (IN4), B15.P1 (IN3), B15.R1 (IN4), B15.S2 (IN2), B15.T2 (IN3), B15.U2 (IN4), B16.V1
+3V(18): B16.D1 (IN4), B16.H2 (IN4), B16.K1 (IN4), B16.U1
+3V(19): A19.U1, B18.K2 (R); also elsewhere on the board
+3V(20): A19.V1, B18.N2 (S), B18.R1 (S), B18.U2 (S), B19.A1 (R), B19.D1 (S), B19.F2 (S), B19.K1 (S), B19.K2 (R), B19.N2 (S), B19.R1 (S), B19.U2 (S)
BF0: A16.E2 (IN2), B18.P2 (1)
BF1: A16.M1 (IN2), B18.S1 (1)
BF2: A16.R2 (IN2), B18.V2 (1)
BF_ENABLE: A16.D2 (IN1), A16.L1 (IN1), A16.P2 (IN1), B11.M1 (0)
BMA00: B14.E1 (OUT), H01.K2
BMA01: B14.J2 (OUT), H01.M2
BMA02: B14.L1 (OUT), H01.P2
BMA03: B14.P2 (OUT), H01.S2
BMA04: B14.S1 (OUT), H01.T2
BMA05: B14.V2 (OUT), H01.V2
BMA06: B15.E1 (OUT), H02.D2
BMA07: B15.J2 (OUT), H02.E2
BMA08: B15.L1 (OUT), H02.H2
BMA09: B15.P2 (OUT), H02.K2
BMA10: B15.S1 (OUT), H02.M2
BMA11: B15.V2 (OUT), H02.P2
B_SET: A19.E2 (IN2), A19.M1 (IN2); also elsewhere on the board
B_SET_: A19.F2 (OUT), B11.J1 (D), B20.F2 (IN3)
CLEAR_DF_: B21.S2 (OUT); also elsewhere on the board
CLEAR_IB_: B21.N2 (OUT); also elsewhere on the board
CLEAR_IFDFBF_: B21.L2 (IN1), B21.P1 (IN1), B21.P2 (IN1); also elsewhere on the board
CLEAR_IF_: B21.S1 (OUT); also elsewhere on the board
DEFER: B20.C1 (IN3); also elsewhere on the board
DF0: A16.E1 (IN2), B19.M2 (D); also elsewhere on the board
DF1: A16.J2 (IN2), B19.P1 (D); also elsewhere on the board
DF2: A16.R1 (IN2), B19.T2 (D); also elsewhere on the board
DF_ENABLE: A16.D1 (IN1), A16.H2 (IN1), A16.P1 (IN1), B11.J2 (0)
DF_ENABLE_: B11.E2 (D), B20.D1 (OUT), B20.D2 (IN1)
EA0: B16.E1 (OUT), H01.D2
EA1: B16.J2 (OUT), H01.E2
EA2: B16.L1 (OUT), H01.H2
EXT_DATA_ADD0: B18.M2 (D); also elsewhere on the board
EXT_DATA_ADD1: B18.P1 (D); also elsewhere on the board
EXT_DATA_ADD2: B18.T2 (D); also elsewhere on the board
GND: A13.C2 (GND), A13.T1 (GND), A16.C2 (GND), A16.T1 (GND), A19.C2 (GND), A19.T1 (GND), B10.C2 (GND), B11.C2 (GND), B11.T1 (GND), B12.C2 (GND), B12.T1 (GND), B13.C2 (GND), B13.T1 (GND), B14.C2 (GND), B14.T1 (GND), B15.C2 (GND), B15.T1 (GND), B16.C2 (GND), B16.T1 (GND), B18.C2 (GND), B18.T1 (GND), B19.C2 (GND), B19.T1 (GND), B20.C2 (GND), B20.T1 (GND), B21.C2 (GND), B21.T1 (GND), E12.C2 (GND), E12.T1 (GND), H01.C2 (GND), H01.F2 (GND), H01.J2 (GND), H01.L2 (GND), H01.N2 (GND), H01.R2 (GND), H01.U2 (GND), H02.C2 (GND), H02.F2 (GND), H02.J2 (GND), H02.L2 (GND), H02.N2 (GND), H02.R2 (GND), H02.U2 (GND), H03.C2 (GND), H03.F2 (GND), H03.J2 (GND), H03.L2 (GND), H03.N2 (GND), H03.R2 (GND), H03.U2 (GND); also elsewhere on the board
IF0: A16.B1 (IN2), B19.C1 (D); also elsewhere on the board
IF1: A16.J1 (IN2), B19.E2 (D); also elsewhere on the board
IF2: A16.M2 (IN2), B19.J1 (D); also elsewhere on the board
IF_ENABLE: A16.A1 (IN1), A16.H1 (IN1), A16.L2 (IN1), B11.F1 (0)
IF_ENABLE_: B11.C1 (D), B20.H2 (OUT)
IF_TO_SF: A19.S1 (OUT), B19.B1 (C), B19.D2 (C), B21.M2 (IN2), B21.R1 (IN2), B21.R2 (IN2); also elsewhere on the board
JMP_: B20.A1 (IN1); also elsewhere on the board
JMS_: B20.B1 (IN2); also elsewhere on the board
KEY_STEXDP: A19.H2 (IN1); also elsewhere on the board
LOAD_BF: A19.N2 (OUT), B18.L2 (C), B18.N1 (C), B18.S2 (C)
LOAD_SF_: A19.R1 (IN2), A19.R2 (IN2); also elsewhere on the board
MA00_: B14.A1 (IN1); also elsewhere on the board
MA01_: B14.D2 (IN1); also elsewhere on the board
MA02_: B14.F1 (IN1); also elsewhere on the board
MA03_: B14.K2 (IN1); also elsewhere on the board
MA04_: B14.M1 (IN1); also elsewhere on the board
MA05_: B14.R2 (IN1); also elsewhere on the board
MA06_: B15.A1 (IN1); also elsewhere on the board
MA07_: B15.D2 (IN1); also elsewhere on the board
MA08_: B15.F1 (IN1); also elsewhere on the board
MA09_: B15.K2 (IN1); also elsewhere on the board
MA10_: B15.M1 (IN1); also elsewhere on the board
MA11_: B15.R2 (IN1); also elsewhere on the board
MANUAL_PRESET_: B11.D1 (S), B11.F2 (S), B11.K1 (S); also elsewhere on the board
MB00: B12.A1 (IN1); also elsewhere on the board
MB01: B12.D2 (IN1); also elsewhere on the board
MB02: B12.F1 (IN1); also elsewhere on the board
MB03: B12.K2 (IN1); also elsewhere on the board
MB04: B12.M1 (IN1); also elsewhere on the board
MB05: B12.R2 (IN1); also elsewhere on the board
MB06: B13.A1 (IN1); also elsewhere on the board
MB07: B13.D2 (IN1); also elsewhere on the board
MB08: B13.F1 (IN1); also elsewhere on the board
MB09: B13.K2 (IN1); also elsewhere on the board
MB10: B13.M1 (IN1); also elsewhere on the board
MB11: B13.R2 (IN1); also elsewhere on the board
MCBMB00_: B12.E1 (OUT), H02.S2
MCBMB01_: B12.J2 (OUT), H02.T2
MCBMB02_: B12.L1 (OUT), H02.V2
MCBMB03_: B12.P2 (OUT), H03.D2
MCBMB04_: B12.S1 (OUT), H03.E2
MCBMB05_: B12.V2 (OUT), H03.H2
MCBMB06_: B13.E1 (OUT), H03.K2
MCBMB07_: B13.J2 (OUT), H03.M2
MCBMB08_: B13.L1 (OUT), H03.P2
MCBMB09_: B13.P2 (OUT), H03.S2
MCBMB10_: B13.S1 (OUT), H03.T2
MCBMB11_: B13.V2 (OUT), H03.V2
MEM_DONE_: B10.D2; also elsewhere on the board
MFTP1: A19.J2 (IN2), E12.M2 (IN2); also elsewhere on the board
unnamed: A19.P1 (IN1), A19.P2 (IN1), E12.N2 (OUT)
unnamed: A19.C1 (OUT), A19.E1 (IN2)
unnamed: A19.S2 (OUT), B19.H1 (C), B19.L2 (C), B19.N1 (C), B19.S2 (C)
unnamed: A19.F1 (OUT), B20.E2 (IN2)
unnamed: A19.M2 (IN2), A19.N1 (OUT)
unnamed: A19.H1 (IN1), A19.K2 (OUT)
unnamed: A16.F2 (OUT), B16.C1 (IN3)
unnamed: A16.F1 (OUT), B16.B1 (IN2)
unnamed: A16.C1 (OUT), B16.A1 (IN1)
unnamed: A19.K1 (OUT), B11.B1 (C), B11.D2 (C), B11.H1 (C)
unnamed: A16.K1 (OUT), B16.D2 (IN1)
unnamed: A16.K2 (OUT), B16.E2 (IN2)
unnamed: A16.N1 (OUT), B16.F2 (IN3)
unnamed: A16.N2 (OUT), B16.F1 (IN1)
unnamed: A16.S1 (OUT), B16.H1 (IN2)
unnamed: A16.S2 (OUT), B16.J1 (IN3)
RESTART: E12.L2 (IN1); also elsewhere on the board
RUN: B10.J2; also elsewhere on the board
SF0: B19.E1 (1); also elsewhere on the board
SF1: B19.H2 (1); also elsewhere on the board
SF2: B19.L1 (1); also elsewhere on the board
SF3: B19.P2 (1); also elsewhere on the board
SF4: B19.S1 (1); also elsewhere on the board
SF5: B19.V2 (1); also elsewhere on the board
STROBE_: B10.E2; also elsewhere on the board
TP3: A19.L1 (IN1), B10.V2; also elsewhere on the board
TS4_: A19.J1 (IN2); also elsewhere on the board
VCC: A13.A2 (VCC), A16.A2 (VCC), A19.A2 (VCC), B10.A2 (VCC), B11.A2 (VCC), B12.A2 (VCC), B13.A2 (VCC), B14.A2 (VCC), B15.A2 (VCC), B16.A2 (VCC), B18.A2 (VCC), B19.A2 (VCC), B20.A2 (VCC), B21.A2 (VCC), E12.A2 (VCC); also elsewhere on the board
WC_SET_: A19.A1 (IN1); also elsewhere on the board
WORD_COUNT_: A19.B1 (IN2); also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-1 Memory Extension Control (1/2)

Schematic: pdp8i-cpu.sch, sheet 22

Parts:
A06, A11, A12, A13, A14, A15, A16, A17, A18, A19: M113; H807
A20: M115; H807
A40: W077; H807
B11, B17, B18: M216; H807
B16: M617; H807
B20: M115; H807
C12: M617; H807
C40: M900; H807
F09: M119; H807
F11: M117; H807

Connections:
+3V(01): A13.E1 (IN2), A13.H1 (IN1), A13.M1 (IN2), A13.R1 (IN2), A15.U1
+3V(02): A13.U2 (IN2), A14.B1 (IN2), A14.H2 (IN1), A14.J1 (IN2), A14.L1 (IN1), A15.V1
+3V(03): A14.L2 (IN1), A14.P1 (IN1), A15.B1 (IN2), A15.M2 (IN2), A15.P1 (IN1), A18.U1
+3V(04): A18.V1, A19.T2 (IN1); also elsewhere on the board
+3V(08): C12.V1; also elsewhere on the board
+3V(09): A11.V1; also elsewhere on the board
+3V(10): F09.V1; also elsewhere on the board
+3V(19): B17.D1 (S), B17.F2 (S), B17.K1 (S), B17.N2 (S), B17.R1 (S), B17.U2 (S), B18.D1 (S), B18.F2 (S), B18.K1 (S); also elsewhere on the board
+3V(66): A06.R2 (IN2), A11.U1; also elsewhere on the board
+3V(67): A06.M1 (IN2), A06.M2 (IN2), A06.V1; also elsewhere on the board
+3V(68): F09.H2 (IN8), F09.U1; also elsewhere on the board
B_EXT_INST: A06.N1 (OUT), A20.K1 (IN1), A20.N2 (IN1), A20.P1 (IN1); also elsewhere on the board
B_FETCH: B16.K2 (IN1), F09.A1 (IN1); also elsewhere on the board
CLEAR_DF_: B18.A1 (R); also elsewhere on the board
CLEAR_IB_: B17.K2 (R); also elsewhere on the board
CLEAR_IF_: B17.A1 (R); also elsewhere on the board
CUF_: F11.F2 (IN3), F11.H2 (IN4); also elsewhere on the board
DF0: A11.E1 (IN2), B18.E1 (1); also elsewhere on the board
DF0_: B18.F1 (0), C40.J2
DF1: A11.J2 (IN2), B18.H2 (1); also elsewhere on the board
DF1_: B18.J2 (0), C40.S1
DF2: A11.R1 (IN2), B18.L1 (1); also elsewhere on the board
DF2_: B18.M1 (0), C40.P2
DFSR0: A12.E1 (IN2), A40.D2
DFSR1: A12.J2 (IN2), A40.E2
DFSR2: A12.R1 (IN2), A40.F2
EXT_GO: A12.A1 (IN1), A13.F1 (OUT), A15.H2 (IN1), A17.U2 (IN2); also elsewhere on the board
EXT_INST: A14.K2 (OUT), A15.U2 (IN2)
E_SET_: A16.U2 (IN2); also elsewhere on the board
F_SET_: A16.T2 (IN1); also elsewhere on the board
GND: A06.C2 (GND), A06.T1 (GND), A11.C2 (GND), A11.T1 (GND), A12.C2 (GND), A12.T1 (GND), A13.C2 (GND), A13.T1 (GND), A14.C2 (GND), A14.T1 (GND), A15.C2 (GND), A15.T1 (GND), A16.C2 (GND), A16.T1 (GND), A17.C2 (GND), A17.T1 (GND), A18.C2 (GND), A18.T1 (GND), A19.C2 (GND), A19.T1 (GND), A20.C2 (GND), A20.T1 (GND), B11.C2 (GND), B11.P1 (D), B11.T1 (GND), B16.C2 (GND), B16.T1 (GND), B17.C2 (GND), B17.T1 (GND), B18.C2 (GND), B18.T1 (GND), B20.C2 (GND), B20.T1 (GND), C12.C2 (GND), C12.T1 (GND), F09.C2 (GND), F09.T1 (GND), F11.C2 (GND), F11.T1 (GND); also elsewhere on the board
IB0: A17.J1 (IN2), B17.P2 (1)
IB1: A17.M1 (IN2), B17.S1 (1)
IB2: A17.R1 (IN2), B17.V2 (1)
IB_TO_IF: A15.A1 (IN1), A17.C1 (OUT), B17.B1 (C), B17.D2 (C), B17.H1 (C); also elsewhere on the board
IB_TO_IF_: A15.C1 (OUT), B11.R1 (S)
IF0: A11.J1 (IN2), B17.E1 (1); also elsewhere on the board
IF0_: B17.F1 (0), C40.N1
IF1: A11.M2 (IN2), B17.H2 (1); also elsewhere on the board
IF1_: B17.J2 (0), C40.C1
IF2: A11.U2 (IN2), B17.L1 (1); also elsewhere on the board
IF2_: B17.M1 (0), C40.D1
IFSR0: A18.E1 (IN2), A40.H2
IFSR1: A18.J2 (IN2), A40.J2
IFSR2: A18.R1 (IN2), A40.K2
INT_INHIBIT_: B11.S1 (1); also elsewhere on the board
IOT: A14.E1 (IN2), C12.F2 (IN3), C12.H2 (IN4), F09.F2 (IN7); also elsewhere on the board
JMP_: A17.D1 (IN1); also elsewhere on the board
JMS_: A17.E1 (IN2); also elsewhere on the board
KEY_LAMFTS0_: A17.H1 (IN1), A17.L1 (IN1), A17.P1 (IN1), A19.U2 (IN2); also elsewhere on the board
LOAD_IB: A18.C1 (OUT), B17.L2 (C), B17.N1 (C), B17.S2 (C)
MB03_: B16.L2 (IN2), F09.B1 (IN2); also elsewhere on the board
MB04: B16.M2 (IN3), F09.C1 (IN3); also elsewhere on the board
MB05_: B16.N2 (IN4), F09.D1 (IN4); also elsewhere on the board
MB06: A12.E2 (IN2), A15.T2 (IN1), A18.E2 (IN2); also elsewhere on the board
MB06XMB09: A06.N2 (OUT), A06.U2 (IN2); also elsewhere on the board
MB06_: F09.D2 (IN5); also elsewhere on the board
MB07: A12.M1 (IN2), A18.M1 (IN2), A20.R1 (IN2), A20.R2 (IN3); also elsewhere on the board
MB07_: A06.P1 (IN1), A20.L1 (IN2); also elsewhere on the board
MB08: A12.R2 (IN2), A18.R2 (IN2), A20.M1 (IN3), A20.P2 (IN2); also elsewhere on the board
MB08_: A06.R1 (IN2), A20.S1 (IN3); also elsewhere on the board
MB09: A14.D2 (IN1), F09.E2 (IN6); also elsewhere on the board
MB10: A12.B1 (IN2), A15.P2 (IN1); also elsewhere on the board
MB10_: A15.L1 (IN1); also elsewhere on the board
MB11: A11.B1 (IN2); also elsewhere on the board
MB11_: A13.A1 (IN1); also elsewhere on the board
MB_TO_IB: A15.S1 (OUT), A18.D2 (IN1), A18.L1 (IN1), A18.P2 (IN1)
ME06_: A13.N1 (OUT); also elsewhere on the board
ME07_: A13.S1 (OUT); also elsewhere on the board
ME08_: A13.V2 (OUT); also elsewhere on the board
ME09_: A13.K2 (OUT); also elsewhere on the board
ME10_: A13.N2 (OUT); also elsewhere on the board
ME11_: A13.S2 (OUT); also elsewhere on the board
MEM_EXT: A11.A1 (IN1), A13.E2 (IN2), A14.E2 (IN2), A14.K1 (OUT), A15.R2 (IN2)
MEM_EXT_: A14.F1 (OUT), A14.H1 (IN1); also elsewhere on the board
MEM_EXT_AC_LOAD_ENABLE_: A14.S2 (OUT); also elsewhere on the board
MEM_EXT_IO_ENABLE_: C12.J2 (OUT); also elsewhere on the board
unnamed: B11.N1 (C), F11.J2 (OUT)
unnamed: A06.P2 (IN1), A06.S1 (OUT)
unnamed: A06.L2 (IN1), A15.V2 (OUT)
unnamed: A06.S2 (OUT), A06.T2 (IN1)
unnamed: A15.R1 (IN2), A15.S2 (OUT)
unnamed: A15.J2 (IN2), A15.N1 (OUT)
unnamed: A15.J1 (IN2), A19.V2 (OUT)
unnamed: A15.K2 (OUT), A18.B1 (IN2)
unnamed: A18.F2 (OUT), B20.F1 (IN2)
unnamed: A18.K1 (OUT), B20.H1 (IN3)
unnamed: A17.D2 (IN1), A18.F1 (OUT), B20.E1 (IN1)
unnamed: A17.H2 (IN1), A18.K2 (OUT), B20.J2 (IN1)
unnamed: A18.N1 (OUT), B20.K2 (IN2)
unnamed: A18.N2 (OUT), B20.L2 (IN3)
unnamed: A17.L2 (IN1), A18.S1 (OUT), B20.K1 (IN1)
unnamed: A18.S2 (OUT), B20.L1 (IN2)
unnamed: A18.V2 (OUT), B20.M1 (IN3)
unnamed: B17.T2 (D), B20.N1 (OUT)
unnamed: B17.P1 (D), B20.M2 (OUT)
unnamed: B17.M2 (D), B20.J1 (OUT)
unnamed: A17.E2 (IN2), A17.K1 (OUT)
unnamed: A17.J2 (IN2), A17.N1 (OUT)
unnamed: A17.M2 (IN2), A17.S1 (OUT)
unnamed: A17.N2 (OUT), B17.J1 (D)
unnamed: A17.K2 (OUT), B17.E2 (D)
unnamed: A17.F2 (OUT), B17.C1 (D)
unnamed: A16.V2 (OUT), A20.A1 (IN1)
unnamed: A17.F1 (OUT), A20.C1 (IN3)
unnamed: A17.B1 (IN2), A20.D1 (OUT)
unnamed: A06.L1 (IN1), F09.J2 (OUT)
unnamed: A14.A1 (IN1), B16.P2 (OUT)
unnamed: A14.C1 (OUT), A14.D1 (IN1)
unnamed: A14.F2 (OUT), A14.J2 (IN2)
unnamed: A14.M1 (IN2), A20.N1 (OUT), A20.T2 (IN1)
unnamed: A14.M2 (IN2), A20.S2 (OUT), A20.U2 (IN2)
unnamed: A14.R1 (IN2), A20.U1 (OUT), A20.V2 (IN3)
unnamed: A14.R2 (IN2), A20.V1 (OUT), C12.D2 (IN1)
unnamed: A11.D1 (IN1), A11.H2 (IN1), A11.P1 (IN1), A14.N1 (OUT)
unnamed: A11.H1 (IN1), A11.L2 (IN1), A11.T2 (IN1), A14.S1 (OUT)
unnamed: A11.S2 (OUT), A20.K2 (IN2)
unnamed: A11.N1 (OUT), A20.F1 (IN2)
unnamed: A11.F2 (OUT), A20.E2 (IN2)
unnamed: A11.F1 (OUT), A20.D2 (IN1)
unnamed: A11.K1 (OUT), A20.F2 (IN3)
unnamed: A11.N2 (OUT), A20.H1 (IN3)
unnamed: A11.V2 (OUT), A20.L2 (IN3)
unnamed: A11.S1 (OUT), A20.J2 (IN1)
unnamed: A11.K2 (OUT), A20.E1 (IN1)
unnamed: A13.L1 (IN1), A20.H2 (OUT)
unnamed: A13.P1 (IN1), A20.J1 (OUT)
unnamed: A13.T2 (IN1), A20.M2 (OUT)
unnamed: A12.D2 (IN1), A12.L1 (IN1), A12.P2 (IN1), A13.K1 (OUT)
unnamed: A12.S2 (OUT), B20.U2 (IN2)
unnamed: A12.V2 (OUT), B20.V2 (IN3)
unnamed: A12.N2 (OUT), B20.S1 (IN3)
unnamed: A12.N1 (OUT), B20.R1 (IN2)
unnamed: A12.K2 (OUT), B20.P1 (IN1)
unnamed: A12.S1 (OUT), B20.T2 (IN1)
unnamed: A12.K1 (OUT), B20.R2 (IN3)
unnamed: A12.F2 (OUT), B20.P2 (IN2)
unnamed: A12.F1 (OUT), B20.N2 (IN1)
unnamed: B18.C1 (D), B20.S2 (OUT)
unnamed: B18.E2 (D), B20.U1 (OUT)
unnamed: B18.J1 (D), B20.V1 (OUT)
unnamed: A17.S2 (OUT), B18.B1 (C), B18.D2 (C), B18.H1 (C)
unnamed: A11.C1 (OUT), A13.J1 (IN2)
unnamed: A17.P2 (IN1), A17.V2 (OUT)
unnamed: A13.D1 (IN1), A13.F2 (OUT)
unnamed: A13.C1 (OUT), A17.T2 (IN1)
unnamed: A12.C1 (OUT), F11.D2 (IN1), F11.E2 (IN2)
PC_LOAD: A15.H1 (IN1); also elsewhere on the board
PC_LOADXSR_ENABLE_: A15.K1 (OUT), A17.A1 (IN1), A17.R2 (IN2), A18.A1 (IN1); also elsewhere on the board
RIB: A11.D2 (IN1), A11.L1 (IN1), A11.P2 (IN1), A13.H2 (IN1), A13.L2 (IN1), A13.P2 (IN1), A14.N2 (OUT); also elsewhere on the board
RMF_: A06.V2 (OUT), A13.B1 (IN2), A15.L2 (IN1), A15.M1 (IN2); also elsewhere on the board
SF0: A11.E2 (IN2), A18.J1 (IN2); also elsewhere on the board
SF1: A11.M1 (IN2), A18.M2 (IN2); also elsewhere on the board
SF2: A11.R2 (IN2), A18.U2 (IN2); also elsewhere on the board
SF3: A12.J1 (IN2), A13.J2 (IN2); also elsewhere on the board
SF4: A12.M2 (IN2), A13.M2 (IN2); also elsewhere on the board
SF5: A12.U2 (IN2), A13.R2 (IN2); also elsewhere on the board
SF_ENABLE: A12.H1 (IN1), A12.L2 (IN1), A12.T2 (IN1), A15.N2 (OUT), A18.H1 (IN1), A18.L2 (IN1), A18.T2 (IN1); also elsewhere on the board
SR_ENABLE: A12.D1 (IN1), A12.H2 (IN1), A12.P1 (IN1), A18.D1 (IN1), A18.H2 (IN1), A18.P1 (IN1); also elsewhere on the board
TP3: A13.D2 (IN1), A14.P2 (IN1), A20.B1 (IN2); also elsewhere on the board
TS3: C12.E2 (IN2); also elsewhere on the board
VCC: A06.A2 (VCC), A11.A2 (VCC), A12.A2 (VCC), A13.A2 (VCC), A14.A2 (VCC), A15.A2 (VCC), A16.A2 (VCC), A17.A2 (VCC), A18.A2 (VCC), A19.A2 (VCC), A20.A2 (VCC), B11.A2 (VCC), B16.A2 (VCC), B17.A2 (VCC), B18.A2 (VCC), B20.A2 (VCC), C12.A2 (VCC), F09.A2 (VCC), F11.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-1 Memory Extension Control (2/2)
VRS -- substituted latch for cross-coupled gates
+3V

Schematic: pdp8i-cpu.sch, sheet 23

Notes on the sheet:
D-BS-mc8i-0-2 Inhibit Drivers

Schematic: pdp8i-cpu.sch, sheet 24

Notes on the sheet:
D-BS-mc8i-0-3 X Axis Selection

Schematic: pdp8i-cpu.sch, sheet 25

Notes on the sheet:
D-BS-mc8i-0-4 Y Axis Selection
