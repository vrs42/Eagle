# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8I/pdp8i-dec.brd (continued)

Schematic: pdp8i-dec.sch, sheet 14

Parts:
H07, H08, H09, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20: M650; H807
J01, J02, J03, J04, J05, J06, J07, J08, J09, J10, J11: W011; H807
J13, J14, J15, J16, J17, J18, J19, J20: M506; H807

Connections:
3CYCLE: J10.K2, J20.D2 (IN)
3_CYCLE: J20.J2 (OUT); also elsewhere on the board
+3V(49): H07.F2 (IN1), H07.J2 (IN3), H07.M2 (IN1), H07.P2 (IN3), H07.T2 (IN1), H07.V2 (IN3), H08.F2 (IN1), H08.J2 (IN3), H08.M2 (IN1), H08.P2 (IN3), H08.T2 (IN1), H08.V2 (IN3); also elsewhere on the board
+3V(50): H09.F2 (IN1), H09.J2 (IN3), H09.M2 (IN1), H09.P2 (IN3), H09.T2 (IN1), H09.V2 (IN3), H10.F2 (IN1), H10.J2 (IN3), H10.M2 (IN1), H10.P2 (IN3), H10.T2 (IN1), H10.V2 (IN3); also elsewhere on the board
+3V(51): H11.F2 (IN1), H11.J2 (IN3), H11.M2 (IN1), H11.P2 (IN3), H11.T2 (IN1), H11.V2 (IN3), H12.F2 (IN1), H12.J2 (IN3), H12.M2 (IN1), H12.P2 (IN3), H12.T2 (IN1), H12.V2 (IN3); also elsewhere on the board
+3V(52): H13.F2 (IN1), H13.J2 (IN3), H13.M2 (IN1), H13.P2 (IN3), H13.T2 (IN1), H13.V2 (IN3), H14.F2 (IN1), H14.J2 (IN3), H14.M2 (IN1), H14.P2 (IN3), H14.T2 (IN1), H14.V2 (IN3), J13.R1 (IN4); also elsewhere on the board
+3V(53): H15.F2 (IN1), H15.J2 (IN3), H15.M2 (IN1), H15.P2 (IN3), H15.T2 (IN1), H15.V2 (IN3), H16.F2 (IN1), H16.J2 (IN3), H16.M2 (IN1), H16.P2 (IN3), H16.T2 (IN1), H16.V2 (IN3); also elsewhere on the board
+3V(54): H17.F2 (IN1), H17.J2 (IN3), H17.M2 (IN1), H17.P2 (IN3), H17.T2 (IN1), H17.V2 (IN3), H18.F2 (IN1), H18.J2 (IN3), H18.M2 (IN1), H18.P2 (IN3), H18.T2 (IN1), H18.V2 (IN3); also elsewhere on the board
+3V(55): H19.F2 (IN1), H19.J2 (IN3), H19.M2 (IN1), H19.P2 (IN3), H19.T2 (IN1), H19.V2 (IN3), H20.F2 (IN1), H20.J2 (IN3), H20.M2 (IN1), H20.P2 (IN3); also elsewhere on the board
+3V(56): J13.C1 (IN3), J13.D1 (IN4), J13.F2 (IN3), J13.H2 (IN4), J13.J1 (IN3), J13.K1 (IN4), J13.M2 (IN3), J13.N2 (IN4); also elsewhere on the board
-15V: H07.B2 (-15V), H08.B2 (-15V), H09.B2 (-15V), H10.B2 (-15V), H11.B2 (-15V), H12.B2 (-15V), H13.B2 (-15V), H14.B2 (-15V), H15.B2 (-15V), H16.B2 (-15V), H17.B2 (-15V), H18.B2 (-15V), H19.B2 (-15V), H20.B2 (-15V), J13.B2 (-15V), J14.B2 (-15V), J15.B2 (-15V), J16.B2 (-15V), J17.B2 (-15V), J18.B2 (-15V), J19.B2 (-15V), J20.B2 (-15V); also elsewhere on the board
AC00: H07.H2 (IN2); also elsewhere on the board
AC01: H07.N2 (IN2); also elsewhere on the board
AC02: H07.U2 (IN2); also elsewhere on the board
AC03: H08.H2 (IN2); also elsewhere on the board
AC04: H08.N2 (IN2); also elsewhere on the board
AC05: H08.U2 (IN2); also elsewhere on the board
AC06: H09.H2 (IN2); also elsewhere on the board
AC07: H09.N2 (IN2); also elsewhere on the board
AC08: H09.U2 (IN2); also elsewhere on the board
AC09: H10.H2 (IN2); also elsewhere on the board
AC10: H10.N2 (IN2); also elsewhere on the board
AC11: H10.U2 (IN2); also elsewhere on the board
ACCLR: J06.P2, J15.F1 (IN)
AC_CLEAR: J15.L1 (OUT); also elsewhere on the board
ADD_ACCEPTED_: H20.N2 (IN2); also elsewhere on the board
BAC00: H07.D2 (OUT), J01.D2
BAC01: H07.K2 (OUT), J01.E2
BAC02: H07.S2 (OUT), J01.H2
BAC03: H08.D2 (OUT), J01.K2
BAC04: H08.K2 (OUT), J01.M2
BAC05: H08.S2 (OUT), J01.P2
BAC06: H09.D2 (OUT), J01.S2
BAC07: H09.K2 (OUT), J01.T2
BAC08: H09.S2 (OUT), J01.V2
BAC09: H10.D2 (OUT), J02.D2
BAC10: H10.K2 (OUT), J02.E2
BAC11: H10.S2 (OUT), J02.H2
BADD_ACCEPTED_: H20.K2 (OUT), J08.S2
BBREAK: H20.D2 (OUT), J08.P2
BINITIALIZE_: H12.S2 (OUT), J02.V2
BIOP1_: H11.D2 (OUT), J02.K2
BIOP2_: H11.K2 (OUT), J02.M2
BIOP4_: H11.S2 (OUT), J02.P2
BMB00: H13.D2 (OUT), J03.D2
BMB01: H13.K2 (OUT), J03.E2
BMB02: H13.S2 (OUT), J03.H2
BMB03: H14.K2 (OUT), J03.M2
BMB03_: H14.D2 (OUT), J03.K2
BMB04: H15.D2 (OUT), J03.S2
BMB04_: H14.S2 (OUT), J03.P2
BMB05: H15.S2 (OUT), J03.V2
BMB05_: H15.K2 (OUT), J03.T2
BMB06: H16.K2 (OUT), J04.E2
BMB06_: H16.D2 (OUT), J04.D2
BMB07: H17.D2 (OUT), J04.K2
BMB07_: H16.S2 (OUT), J04.H2
BMB08: H17.S2 (OUT), J04.P2
BMB08_: H17.K2 (OUT), J04.M2
BMB09: H18.D2 (OUT), J04.S2
BMB10: H18.K2 (OUT), J04.T2
BMB11: H18.S2 (OUT), J04.V2
BREAK_: H20.H2 (IN2); also elsewhere on the board
BRK_RQST: J15.S1 (OUT); also elsewhere on the board
BRQ: J08.K2, J15.M1 (IN)
BRUN_: H19.D2 (OUT), J06.S2
BTS1: H12.K2 (OUT), J02.T2
BTS3: H12.D2 (OUT), J02.S2
BTT_INST_: H19.K2 (OUT), J06.T2
BWC_OVERFLOW: H19.S2 (OUT), J10.P2
CA_INCREMENT_: J20.L1 (OUT); also elsewhere on the board
CA_INCR_: J10.M2, J20.F1 (IN)
CLOCK_AC_CLR_: J15.K1 (IN4); also elsewhere on the board
D00: J09.D2, J18.A1 (IN)
D01: J09.E2, J18.D2 (IN)
D02: J09.H2, J18.F1 (IN)
D03: J09.K2, J18.K2 (IN)
D04: J09.M2, J18.M1 (IN)
D05: J09.P2, J18.R2 (IN)
D06: J09.S2, J19.A1 (IN)
D07: J09.T2, J19.D2 (IN)
D08: J09.V2, J19.F1 (IN)
D09: J10.D2, J19.K2 (IN)
D10: J10.E2, J19.M1 (IN)
D11: J10.H2, J19.R2 (IN)
DA00: J07.D2, J16.A1 (IN)
DA01: J07.E2, J16.D2 (IN)
DA02: J07.H2, J16.F1 (IN)
DA03: J07.K2, J16.K2 (IN)
DA04: J07.M2, J16.M1 (IN)
DA05: J07.P2, J16.R2 (IN)
DA06: J07.S2, J17.A1 (IN)
DA07: J07.T2, J17.D2 (IN)
DA08: J07.V2, J17.F1 (IN)
DA09: J08.D2, J17.K2 (IN)
DA10: J08.E2, J17.M1 (IN)
DA11: J08.H2, J17.R2 (IN)
DATA00: J18.E1 (OUT); also elsewhere on the board
DATA01: J18.J2 (OUT); also elsewhere on the board
DATA02: J18.L1 (OUT); also elsewhere on the board
DATA03: J18.P2 (OUT); also elsewhere on the board
DATA04: J18.S1 (OUT); also elsewhere on the board
DATA05: J18.V2 (OUT); also elsewhere on the board
DATA06: J19.E1 (OUT); also elsewhere on the board
DATA07: J19.J2 (OUT); also elsewhere on the board
DATA08: J19.L1 (OUT); also elsewhere on the board
DATA09: J19.P2 (OUT); also elsewhere on the board
DATA10: J19.S1 (OUT); also elsewhere on the board
DATA11: J19.V2 (OUT); also elsewhere on the board
DATA_ADD00: J16.E1 (OUT); also elsewhere on the board
DATA_ADD01: J16.J2 (OUT); also elsewhere on the board
DATA_ADD02: J16.L1 (OUT); also elsewhere on the board
DATA_ADD03: J16.P2 (OUT); also elsewhere on the board
DATA_ADD04: J16.S1 (OUT); also elsewhere on the board
DATA_ADD05: J16.V2 (OUT); also elsewhere on the board
DATA_ADD06: J17.E1 (OUT); also elsewhere on the board
DATA_ADD07: J17.J2 (OUT); also elsewhere on the board
DATA_ADD08: J17.L1 (OUT); also elsewhere on the board
DATA_ADD09: J17.P2 (OUT); also elsewhere on the board
DATA_ADD10: J17.S1 (OUT); also elsewhere on the board
DATA_ADD11: J17.V2 (OUT); also elsewhere on the board
DATA_IN_: J15.V2 (OUT); also elsewhere on the board
D_IN_: J08.M2, J15.R2 (IN)
EDA0: J10.V2, J11.H2, J20.K2 (IN)
EDA1: J10.T2, J11.E2, J20.M1 (IN)
EDA2: J10.S2, J11.D2, J20.R2 (IN)
EXT_DATA_ADD0: J20.P2 (OUT); also elsewhere on the board
EXT_DATA_ADD1: J20.S1 (OUT); also elsewhere on the board
EXT_DATA_ADD2: J20.V2 (OUT); also elsewhere on the board
GND: H07.C2 (GND), H07.E2 (SLOW), H07.L2 (SLOW), H07.R2 (SLOW), H08.C2 (GND), H08.E2 (SLOW), H08.L2 (SLOW), H08.R2 (SLOW), H09.C2 (GND), H09.E2 (SLOW), H09.L2 (SLOW), H09.R2 (SLOW), H10.C2 (GND), H10.E2 (SLOW), H10.L2 (SLOW), H10.R2 (SLOW), H11.C2 (GND), H11.E2 (SLOW), H11.L2 (SLOW), H11.R2 (SLOW), H12.C2 (GND), H12.E2 (SLOW), H12.L2 (SLOW), H12.R2 (SLOW), H13.C2 (GND), H13.E2 (SLOW), H13.L2 (SLOW), H13.R2 (SLOW), H14.C2 (GND), H14.E2 (SLOW), H14.L2 (SLOW), H14.R2 (SLOW), H15.C2 (GND), H15.E2 (SLOW), H15.L2 (SLOW), H15.R2 (SLOW), H16.C2 (GND), H16.E2 (SLOW), H16.L2 (SLOW), H16.R2 (SLOW), H17.C2 (GND), H17.E2 (SLOW), H17.L2 (SLOW), H17.R2 (SLOW), H18.C2 (GND), H18.E2 (SLOW), H18.L2 (SLOW), H18.R2 (SLOW), H19.C2 (GND), H19.E2 (SLOW), H19.L2 (SLOW), H19.R2 (SLOW), H20.C2 (GND), H20.E2 (SLOW), H20.L2 (SLOW), J01.C2 (GND), J01.F2 (GND), J01.J2 (GND), J01.L2 (GND), J01.N2 (GND), J01.R2 (GND), J01.U2 (GND), J02.C2 (GND), J02.F2 (GND), J02.J2 (GND), J02.L2 (GND), J02.N2 (GND), J02.R2 (GND), J02.U2 (GND), J03.C2 (GND), J03.F2 (GND), J03.J2 (GND), J03.L2 (GND), J03.N2 (GND), J03.R2 (GND), J03.U2 (GND), J04.C2 (GND), J04.F2 (GND), J04.J2 (GND), J04.L2 (GND), J04.N2 (GND), J04.R2 (GND), J04.U2 (GND), J05.C2 (GND), J05.F2 (GND), J05.J2 (GND), J05.L2 (GND), J05.N2 (GND), J05.R2 (GND), J05.U2 (GND), J06.C2 (GND), J06.F2 (GND), J06.J2 (GND), J06.L2 (GND), J06.N2 (GND), J06.R2 (GND), J06.U2 (GND), J07.C2 (GND), J07.F2 (GND), J07.J2 (GND), J07.L2 (GND), J07.N2 (GND), J07.R2 (GND), J07.U2 (GND), J08.C2 (GND), J08.F2 (GND), J08.J2 (GND), J08.L2 (GND), J08.N2 (GND), J08.R2 (GND), J08.U2 (GND), J09.C2 (GND), J09.F2 (GND), J09.J2 (GND), J09.L2 (GND), J09.N2 (GND), J09.R2 (GND), J09.U2 (GND), J10.C2 (GND), J10.F2 (GND), J10.J2 (GND), J10.L2 (GND), J10.N2 (GND), J10.R2 (GND), J10.U2 (GND), J11.C2 (GND), J11.F2 (GND), J11.J2 (GND), J11.L2 (GND), J11.N2 (GND), J11.R2 (GND), J11.U2 (GND), J13.C2 (GND), J13.T1 (GND), J14.C2 (GND), J14.T1 (GND), J15.C2 (GND), J15.T1 (GND), J16.C2 (GND), J16.T1 (GND), J17.C2 (GND), J17.T1 (GND), J18.C2 (GND), J18.T1 (GND), J19.C2 (GND), J19.T1 (GND), J20.C2 (GND), J20.T1 (GND); also elsewhere on the board
IN00: J05.D2, J13.A1 (IN)
IN01: J05.E2, J13.D2 (IN)
IN02: J05.H2, J13.F1 (IN)
IN03: J05.K2, J13.K2 (IN)
IN04: J05.M2, J13.M1 (IN)
IN05: J05.P2, J13.R2 (IN)
IN06: J05.S2, J14.A1 (IN)
IN07: J05.T2, J14.D2 (IN)
IN08: J05.V2, J14.F1 (IN)
IN09: J06.D2, J14.K2 (IN)
IN10: J06.E2, J14.M1 (IN)
IN11: J06.H2, J14.R2 (IN)
INITIALIZE_: H12.U2 (IN2); also elsewhere on the board
INPUT_BUS00: J13.E1 (OUT); also elsewhere on the board
INPUT_BUS01: J13.J2 (OUT); also elsewhere on the board
INPUT_BUS02: J13.L1 (OUT); also elsewhere on the board
INPUT_BUS03: J13.P2 (OUT); also elsewhere on the board
INPUT_BUS04: J13.S1 (OUT); also elsewhere on the board
INPUT_BUS05: J13.V2 (OUT); also elsewhere on the board
INPUT_BUS06: J14.E1 (OUT); also elsewhere on the board
INPUT_BUS07: J14.J2 (OUT); also elsewhere on the board
INPUT_BUS08: J14.L1 (OUT); also elsewhere on the board
INPUT_BUS09: J14.P2 (OUT); also elsewhere on the board
INPUT_BUS10: J14.S1 (OUT); also elsewhere on the board
INPUT_BUS11: J14.V2 (OUT); also elsewhere on the board
INT_RQST: J15.J2 (OUT); also elsewhere on the board
IOP1_: H11.H2 (IN2); also elsewhere on the board
IOP2_: H11.N2 (IN2); also elsewhere on the board
IOP4_: H11.U2 (IN2); also elsewhere on the board
IO_BUS_IN00_: J13.B1 (IN2); also elsewhere on the board
IO_BUS_IN01_: J13.E2 (IN2); also elsewhere on the board
IO_BUS_IN02_: J13.H1 (IN2); also elsewhere on the board
IO_BUS_IN03_: J13.L2 (IN2); also elsewhere on the board
IO_BUS_IN04_: J13.N1 (IN2); also elsewhere on the board
IO_BUS_IN05_: J13.S2 (IN2); also elsewhere on the board
IO_BUS_IN06_: J14.B1 (IN2); also elsewhere on the board
IO_BUS_IN07_: J14.E2 (IN2); also elsewhere on the board
IO_BUS_IN08_: J14.H1 (IN2); also elsewhere on the board
IO_BUS_IN09_: J14.L2 (IN2); also elsewhere on the board
IO_BUS_IN10_: J14.N1 (IN2); also elsewhere on the board
IO_BUS_IN11_: J14.S2 (IN2); also elsewhere on the board
IO_BUS_IN_AC_CLR_: J15.H1 (IN2)
IO_BUS_IN_INT_: J15.E2 (IN2); also elsewhere on the board
IO_BUS_IN_SKIP_: J15.B1 (IN2); also elsewhere on the board
IO_SKIP: J15.E1 (OUT); also elsewhere on the board
IRQ: J06.M2, J15.D2 (IN)
LINE_: J15.P2 (OUT); also elsewhere on the board
LINE_IN: J06.V2, J15.K2 (IN)
MB00: H13.H2 (IN2); also elsewhere on the board
MB01: H13.N2 (IN2); also elsewhere on the board
MB02: H13.U2 (IN2); also elsewhere on the board
MB03: H14.N2 (IN2); also elsewhere on the board
MB03_: H14.H2 (IN2); also elsewhere on the board
MB04: H15.H2 (IN2); also elsewhere on the board
MB04_: H14.U2 (IN2); also elsewhere on the board
MB05: H15.U2 (IN2); also elsewhere on the board
MB05_: H15.N2 (IN2); also elsewhere on the board
MB06: H16.N2 (IN2); also elsewhere on the board
MB06_: H16.H2 (IN2); also elsewhere on the board
MB07: H17.H2 (IN2); also elsewhere on the board
MB07_: H16.U2 (IN2); also elsewhere on the board
MB08: H17.U2 (IN2); also elsewhere on the board
MB08_: H17.N2 (IN2); also elsewhere on the board
MB09: H18.H2 (IN2); also elsewhere on the board
MB10: H18.N2 (IN2); also elsewhere on the board
MB11: H18.U2 (IN2); also elsewhere on the board
ME05_: J13.U2 (IN4); also elsewhere on the board
ME06_: J14.D1 (IN4); also elsewhere on the board
ME07_: J14.H2 (IN4); also elsewhere on the board
ME08_: J14.K1 (IN4); also elsewhere on the board
ME09_: J14.N2 (IN4); also elsewhere on the board
ME10_: J14.R1 (IN4); also elsewhere on the board
ME11_: J14.U2 (IN4); also elsewhere on the board
MEMORY_INCREMENT: J20.E1 (OUT); also elsewhere on the board
MEM_INCR: J08.T2, J20.A1 (IN)
MP_INT_: J15.H2 (IN4); also elsewhere on the board
MP_SKIP_: J15.D1 (IN4); also elsewhere on the board
unnamed: J16.E2 (IN2), J16.F2 (IN3), J16.H2 (IN4)
unnamed: J16.N1 (IN2), J16.P1 (IN3), J16.R1 (IN4)
unnamed: J16.B1 (IN2), J16.C1 (IN3), J16.D1 (IN4)
unnamed: J16.H1 (IN2), J16.J1 (IN3), J16.K1 (IN4)
unnamed: J16.L2 (IN2), J16.M2 (IN3), J16.N2 (IN4)
unnamed: J16.S2 (IN2), J16.T2 (IN3), J16.U2 (IN4)
unnamed: J17.N1 (IN2), J17.P1 (IN3), J17.R1 (IN4)
unnamed: J17.B1 (IN2), J17.C1 (IN3), J17.D1 (IN4)
unnamed: J17.E2 (IN2), J17.F2 (IN3), J17.H2 (IN4)
unnamed: J17.H1 (IN2), J17.J1 (IN3), J17.K1 (IN4)
unnamed: J17.L2 (IN2), J17.M2 (IN3), J17.N2 (IN4)
unnamed: J17.S2 (IN2), J17.T2 (IN3), J17.U2 (IN4)
unnamed: J19.S2 (IN2), J19.T2 (IN3), J19.U2 (IN4)
unnamed: J19.N1 (IN2), J19.P1 (IN3), J19.R1 (IN4)
unnamed: J19.L2 (IN2), J19.M2 (IN3), J19.N2 (IN4)
unnamed: J19.H1 (IN2), J19.J1 (IN3), J19.K1 (IN4)
unnamed: J19.E2 (IN2), J19.F2 (IN3), J19.H2 (IN4)
unnamed: J19.B1 (IN2), J19.C1 (IN3), J19.D1 (IN4)
unnamed: J18.S2 (IN2), J18.T2 (IN3), J18.U2 (IN4)
unnamed: J18.N1 (IN2), J18.P1 (IN3), J18.R1 (IN4)
unnamed: J18.L2 (IN2), J18.M2 (IN3), J18.N2 (IN4)
unnamed: J18.H1 (IN2), J18.J1 (IN3), J18.K1 (IN4)
unnamed: J18.E2 (IN2), J18.F2 (IN3), J18.H2 (IN4)
unnamed: J18.B1 (IN2), J18.C1 (IN3), J18.D1 (IN4)
unnamed: J15.L2 (IN2), J15.M2 (IN3), J15.N2 (IN4)
unnamed: J15.S2 (IN2), J15.T2 (IN3), J15.U2 (IN4)
unnamed: J15.N1 (IN2), J15.P1 (IN3), J15.R1 (IN4)
unnamed: J20.B1 (IN2), J20.C1 (IN3), J20.D1 (IN4)
unnamed: J20.E2 (IN2), J20.F2 (IN3), J20.H2 (IN4)
unnamed: J20.H1 (IN2), J20.J1 (IN3), J20.K1 (IN4)
unnamed: J20.N1 (IN2), J20.P1 (IN3), J20.R1 (IN4)
unnamed: J20.L2 (IN2), J20.M2 (IN3), J20.N2 (IN4)
unnamed: J20.S2 (IN2), J20.T2 (IN3), J20.U2 (IN4)
RUN_: H19.H2 (IN2); also elsewhere on the board
SKIPB: J06.K2, J15.A1 (IN)
TS1_: H12.N2 (IN2); also elsewhere on the board
TS3_: H12.H2 (IN2); also elsewhere on the board
TT0_: J13.P1 (IN3); also elsewhere on the board
TT1_: J13.T2 (IN3); also elsewhere on the board
TT2_: J14.C1 (IN3); also elsewhere on the board
TT3_: J14.F2 (IN3); also elsewhere on the board
TT4_: J14.J1 (IN3); also elsewhere on the board
TT5_: J14.M2 (IN3); also elsewhere on the board
TT6_: J14.P1 (IN3); also elsewhere on the board
TT7_: J14.T2 (IN3); also elsewhere on the board
TT_AC_CLR_: J15.J1 (IN3); also elsewhere on the board
TT_INST_: H19.N2 (IN2); also elsewhere on the board
TT_INT_: J15.F2 (IN3); also elsewhere on the board
TT_SKIP_: J15.C1 (IN3); also elsewhere on the board
VCC: H07.A2 (VCC), H08.A2 (VCC), H09.A2 (VCC), H10.A2 (VCC), H11.A2 (VCC), H12.A2 (VCC), H13.A2 (VCC), H14.A2 (VCC), H15.A2 (VCC), H16.A2 (VCC), H17.A2 (VCC), H18.A2 (VCC), H19.A2 (VCC), H20.A2 (VCC), J13.A2 (VCC), J14.A2 (VCC), J15.A2 (VCC), J16.A2 (VCC), J17.A2 (VCC), J18.A2 (VCC), J19.A2 (VCC), J20.A2 (VCC); also elsewhere on the board
WC_OVERFLOW_: H19.U2 (IN2); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-10 I/O Level Converter
8i-00009?
1. For ka8i, substitute D-BS-ka8i-0-1 for this print.
2. G717 is always placed at the end of the I/O bus.
(Place G717 in location J02 if no options on the I/O bus.)

Schematic: pdp8i-dec.sch, sheet 15

Parts:
EF01: M706; H807-2
J12: W076; H807

Connections:
+3V(33): EF01.BR1; also elsewhere on the board
-15V: J12.B2 (-15V); also elsewhere on the board
-30V: J12.V2 (-30V); also elsewhere on the board
CLOCK_SCALE_2: EF01.BP2, EF01.BT2, EF01.BU1
GND: EF01.AC2 (GND), EF01.AT1 (GND), EF01.BC2 (GND), EF01.BD1, EF01.BT1 (GND), J12.C2 (GND); also elsewhere on the board
INITIALIZE: EF01.BF2; also elsewhere on the board
IN_STOP_2_: EF01.BR2, EF01.BV2
IOP1: EF01.BD2; also elsewhere on the board
IOP2: EF01.BJ2; also elsewhere on the board
IOP4: EF01.AL2; also elsewhere on the board
KCC_: EF01.AE2, EF01.AV2
KEYBOARD_FLAG_: EF01.AF2; also elsewhere on the board
MB03_: EF01.AD2; also elsewhere on the board
MB04_: EF01.AE1; also elsewhere on the board
MB05_: EF01.AF1; also elsewhere on the board
MB06_: EF01.AH1; also elsewhere on the board
MB07: EF01.AH2; also elsewhere on the board
MB08: EF01.AJ1; also elsewhere on the board
READER_RUN_: EF01.AU2, J12.M2
RX_DATA: EF01.BM2, J12.E2
TT0_: EF01.AK2; also elsewhere on the board
TT1_: EF01.AR2; also elsewhere on the board
TT2_: EF01.AS2; also elsewhere on the board
TT3_: EF01.AL1; also elsewhere on the board
TT4_: EF01.AM1; also elsewhere on the board
TT5_: EF01.AP2; also elsewhere on the board
TT6_: EF01.AT2; also elsewhere on the board
TT7_: EF01.AN2; also elsewhere on the board
TTI2: EF01.AJ2, EF01.AK1
TTI_CLOCK: EF01.AN1; also elsewhere on the board
TTI_DATA: EF01.AM2, EF01.AR1
TTI_SKIP_: EF01.BH2; also elsewhere on the board
TT_AC_CLR_: EF01.BE2; also elsewhere on the board
VCC: EF01.AA2 (VCC), EF01.BA2 (VCC), J12.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-11 Teletype Receivers
Note: The backplane, as drawn, is configured for:
8 bit characters
2 stop bits
03 device code
Backplane wiring changes would be needed to change these settings.
This may be an issue for non-wire-wrap-backplanes.
Teletype Receiver

Schematic: pdp8i-dec.sch, sheet 16

Parts:
E12: M113; H807
EF02: M707; H807-2
F03: M452; H807
F19: M117; H807
J12: W076; H807

Connections:
+3V(33): E12.R1 (IN2), E12.T2 (IN1), EF02.AN1, EF02.AN2, EF02.BF2, EF02.BJ1, EF02.BS2; also elsewhere on the board
+3V(43): F19.N2 (IN4); also elsewhere on the board
-15V: J12.B2 (-15V); also elsewhere on the board
AC04: EF02.AP2; also elsewhere on the board
AC05: EF02.AR2; also elsewhere on the board
AC06: EF02.AL2; also elsewhere on the board
AC07: EF02.AM2; also elsewhere on the board
AC08: EF02.AU2; also elsewhere on the board
AC09: EF02.AS2; also elsewhere on the board
AC10: EF02.AT2; also elsewhere on the board
AC11: EF02.AU1; also elsewhere on the board
ENABLE: EF02.AK1, EF02.AK2
ENABLE_: EF02.AH1, EF02.AL1
GND: E12.C2 (GND), E12.T1 (GND), EF02.AC2 (GND), EF02.AT1 (GND), EF02.BC2 (GND), EF02.BT1 (GND), F03.C2 (GND), F19.C2 (GND), F19.T1 (GND), J12.C2 (GND); also elsewhere on the board
HZ880: F03.J2, F03.P2
INITIALIZE: EF02.BE2; also elsewhere on the board
IOP1: EF02.BH2; also elsewhere on the board
IOP2: EF02.BD2; also elsewhere on the board
IOP4: EF02.AS1; also elsewhere on the board
KEYBOARD_FLAG_: F19.P1 (IN3); also elsewhere on the board
MB03_: EF02.AE2; also elsewhere on the board
MB04_: EF02.AE1; also elsewhere on the board
MB05_: EF02.AF2; also elsewhere on the board
MB06: EF02.AF1; also elsewhere on the board
MB07_: EF02.AH2; also elsewhere on the board
MB08_: EF02.AJ2; also elsewhere on the board
unnamed: E12.U2 (IN2), F19.S1 (OUT)
unnamed: E12.P1 (IN1), F19.P2 (OUT)
OUT_STOP2_: EF02.BN1, EF02.BN2
PWR_LOW_: F19.M1 (IN1); also elsewhere on the board
PWR_SKIP_: F19.M2 (IN3); also elsewhere on the board
TELEPRINTER_FLAG_: EF02.BK2, F19.R1 (IN4)
TTI_CLOCK: F03.R2; also elsewhere on the board
TTI_SKIP_: F19.K2 (IN1); also elsewhere on the board
TTO_CLOCK_: EF02.BP2, F03.K2
TTO_SKIP_: EF02.BJ2, F19.L2 (IN2)
TT_INT_: E12.V2 (OUT); also elsewhere on the board
TT_SKIP_: E12.S1 (OUT); also elsewhere on the board
TX_DATA: EF02.AV2, J12.H2
UINT_: F19.N1 (IN2); also elsewhere on the board
VCC: E12.A2 (VCC), EF02.AA2 (VCC), EF02.BA2 (VCC), F03.A2 (VCC), F19.A2 (VCC), J12.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-12 Teletype Transmitter
Note: The backplane, as drawn, is configured for:
8 bit characters
2 stop bits
04 device code
Backplane wiring changes would be needed to change these settings.
This may be an issue for non-wire-wrap-backplanes.

Schematic: pdp8i-dec.sch, sheet 17

Parts:
A21, A22, A23, A24: M310; H807
A38, A39: G624; H807
AB01: G805; H807-2
AB02: G826; H807-2
AB03: G792; H807-2
AB35: W025; H807-2
B21: M113; H807
B22: M216; H807
B23, B24: M360; H807
B30: M617; H807
B38, B39: G624; H807
C12: M617; H807
C39: G228; H807
D07: M113; H807
D08: M310; H807
D39: G228; H807
E09: M113; H807

Connections:
+3V(21): B21.B1 (IN2), B21.E2 (IN2), B21.H1 (IN1), B21.J2 (IN2), B21.U1, B22.D1 (S), B22.F2 (S), B30.B1 (IN2), B30.C1 (IN3), B30.D1 (IN4), B30.D2 (IN1)
+3V(22): B30.E2 (IN2), B30.F2 (IN3), B30.H1 (IN2), B30.J1 (IN3), B30.K1 (IN4), B30.L2 (IN2), B30.M2 (IN3), B30.N1 (IN2), B30.N2 (IN4), B30.P1 (IN3), B30.R1 (IN4), B30.S2 (IN2), B30.T2 (IN3), B30.U2 (IN4), D39.A1, D39.E2, D39.N2; also elsewhere on the board
+3V(42): C39.D1, C39.L1, D39.D1, D39.L1; also elsewhere on the board
+3V(58): D07.H2 (IN1), D07.L2 (IN1); also elsewhere on the board
+3V(61): C12.B1 (IN2), C12.C1 (IN3), C12.D1 (IN4); also elsewhere on the board
-6V: A38.H2, A38.J2, A38.U2, A39.E2, A39.J2, A39.U2, AB01.BM2 (-6V), AB01.BN2 (-6V), AB01.BP2 (-6V), AB01.BR2 (-6V), AB01.BS2 (-6V), AB01.BT2 (-6V), AB01.BU2 (-6V), AB01.BV2 (-6V), AB02.BM2 (-6V), B38.E2; also elsewhere on the board
-15V: A38.B2, A39.B2, AB02.AB2 (-15V), AB03.BK2 (-15V), AB03.BL2 (-15V), AB03.BM2 (-15V), AB03.BN2 (-15V), AB03.BP2 (-15V), AB03.BR2 (-15V), AB03.BS2 (-15V), AB03.BT2 (-15V), AB03.BU2 (-15V), AB03.BV2 (-15V), B38.B2, B39.B2; also elsewhere on the board
-30V: A39.H2, A39.M2, AB01.AE2 (-30V), AB01.AF2 (-30V), AB01.AH2 (-30V), AB01.AJ2 (-30V), AB01.AK2 (-30V), AB01.AL2 (-30V), AB01.AM2 (-30V), AB01.AN2 (-30V), AB02.BV2 (-30V), B38.H2, B38.J2, B38.U2, B39.H2, B39.J2, B39.U2; also elsewhere on the board
BB_FIELD: C12.E1 (OUT); also elsewhere on the board
BB_FIELD_: B30.L1 (OUT); also elsewhere on the board
B_FIELD: B30.J2 (OUT); also elsewhere on the board
B_FIELD_: B30.V2 (OUT); also elsewhere on the board
B_INHIBIT: B30.P2 (OUT); also elsewhere on the board
B_MEM_ENABLE: B30.E1 (OUT); also elsewhere on the board
B_POWER_CLEAR_: B22.A1 (R), B22.K2 (R), C12.S1 (OUT); also elsewhere on the board
EA0_: B21.L1 (IN1); also elsewhere on the board
EA1_: B21.M1 (IN2); also elsewhere on the board
EA2: B22.E2 (D); also elsewhere on the board
FIELD: B22.H2 (1), B24.R2 (R), B30.F1 (IN1), B30.R2 (IN1)
FIELD_: B22.J2 (0), B23.R2 (R), B30.H2 (IN4), C12.A1 (IN1)
GND: A21.C2 (GND), A21.T1 (GND), A22.C2 (GND), A22.T1 (GND), A23.C2 (GND), A23.T1 (GND), A24.C2 (GND), A24.T1 (GND), A38.E2, AB01.AP2 (GND), AB01.AR2 (GND), AB01.AS2 (GND), AB01.AT2 (GND), AB01.AU2 (GND), AB01.BC2 (GND), AB01.BD2 (GND), AB01.BE2 (GND), AB01.BF2 (GND), AB01.BH2 (GND), AB01.BJ2 (GND), AB01.BK2 (GND), AB01.BL2 (GND), AB02.AC2 (GND), AB02.BC2 (GND), AB03.AD1 (GND), AB03.AE1 (GND), AB03.AF1 (GND), AB03.AH1 (GND), AB03.AJ1 (GND), AB03.AK1 (GND), AB03.AL1 (GND), AB03.AM1 (GND), AB03.AN1 (GND), AB03.AP1 (GND), AB03.AR1 (GND), AB03.AS1 (GND), AB03.AT1 (GND), AB03.AU1 (GND), AB03.AV1 (GND), AB03.BD1 (GND), AB03.BE1 (GND), AB03.BF1 (GND), AB03.BH1 (GND), AB03.BJ1 (GND), AB03.BK1 (GND), AB03.BL1 (GND), AB03.BM1 (GND), AB03.BN1 (GND), AB03.BP1 (GND), AB03.BR1 (GND), AB03.BS1 (GND), AB03.BT1 (GND), AB03.BU1 (GND), AB03.BV1 (GND), B21.C2 (GND), B21.T1 (GND), B22.C2 (GND), B22.J1 (D), B22.M2 (D), B22.P1 (D), B22.T1 (GND), B23.C2 (GND), B24.C2 (GND), B30.C2 (GND), B30.T1 (GND), B39.E2, C12.C2 (GND), C12.T1 (GND), C39.C2 (GND), C39.T1 (GND), D07.C2 (GND), D07.T1 (GND), D08.C2 (GND), D08.T1 (GND), D39.C2 (GND), D39.T1 (GND), E09.C2 (GND), E09.T1 (GND); also elsewhere on the board
INHIBIT_: B22.R2 (0), B30.K2 (IN1)
MEM_BEGIN_: B22.K1 (S), B30.S1 (OUT); also elsewhere on the board
MEM_DONE_: B23.V2 (OUT); also elsewhere on the board
MEM_ENABLE_: B22.F1 (0), B30.A1 (IN1)
MEM_FINISH: A24.F1 (OUT), B22.L2 (C), B22.N1 (C), B23.U2 (IN)
MEM_START: B21.E1 (IN2), B22.B1 (C); also elsewhere on the board
unnamed: AB02.BS2, AB35.BT2
unnamed: AB02.BR2, AB35.BS2
unnamed: AB01.AV2, AB02.BJ2, AB02.BK2
unnamed: B21.V2 (OUT), C12.M1 (IN1), C12.N1 (IN2), C12.P1 (IN3), C12.R1 (IN4)
unnamed: B21.H2 (IN1), B21.N1 (OUT)
unnamed: B21.D1 (IN1), B21.K2 (OUT), B22.C1 (D)
unnamed: B21.A1 (IN1), B21.F1 (OUT)
unnamed: A21.H2, B21.C1 (OUT), B22.D2 (C)
unnamed: A23.H1 (IN), A23.N2
unnamed: A38.F2, C39.U2, D39.U2
unnamed: A21.E1 (IN), A21.L2
unnamed: A39.F2, C39.L2, D39.L2
unnamed: B39.F2, C39.M1, D39.M1
unnamed: B38.F2, C39.E1, D39.E1
unnamed: A21.H1 (IN), A21.N2
unnamed: A21.F1 (OUT), B30.M1 (IN1)
unnamed: A21.J1 (OUT), A22.H2, B23.P2, B24.P2
unnamed: A22.E1 (IN), A22.R2
unnamed: A22.F1 (OUT), B22.H1 (C), D07.M1 (IN2), E09.E2 (IN2)
unnamed: E09.F2 (OUT), E09.J1 (IN2)
unnamed: D07.M2 (IN2), D07.N1 (OUT)
unnamed: D07.N2 (OUT), D08.H2
unnamed: D08.E1 (IN), D08.R2
unnamed: D07.K2 (OUT), E09.H1 (IN1)
unnamed: D07.J2 (IN2), D08.F1 (OUT)
unnamed: A23.H2, E09.K1 (OUT)
unnamed: A23.E1 (IN), A23.M2
unnamed: A23.J1 (OUT), A24.H2, B21.J1 (IN2)
unnamed: A24.E1 (IN), A24.T2
unnamed: B21.F2 (OUT), B22.N2 (S)
unnamed: A23.F1 (OUT), B21.D2 (IN1)
unnamed: B21.K1 (OUT), B22.R1 (S)
NEG_CLAMP: A39.R2, C39.V2, D39.V2; also elsewhere on the board
POWER_CLEAR_: AB02.AS2, B21.T2 (IN1), B21.U2 (IN2)
POWER_OK_: AB02.AJ2; also elsewhere on the board
READ: B22.L1 (1), C39.D2, C39.M2, D39.D2, D39.M2
S: D07.L1 (IN1); also elsewhere on the board
SHUT_DOWN_: AB02.AF2; also elsewhere on the board
STOP_OK: AB02.AH2; also elsewhere on the board
STROBE_: B23.T2 (T), B24.T2 (T); also elsewhere on the board
STROBE_FIELD0: B23.S2 (S); also elsewhere on the board
STROBE_FIELD1: B24.S2 (S); also elsewhere on the board
S_: E09.D2 (IN1); also elsewhere on the board
VCC: A21.A2 (VCC), A22.A2 (VCC), A23.A2 (VCC), A24.A2 (VCC), AB02.AA2 (VCC), AB02.BA2 (VCC), AB03.AD2 (VCC), AB03.AE2 (VCC), AB03.AF2 (VCC), AB03.AH2 (VCC), AB03.AJ2 (VCC), AB03.AK2 (VCC), AB03.AL2 (VCC), AB03.AM2 (VCC), AB03.AN2 (VCC), AB03.AP2 (VCC), AB03.AR2 (VCC), AB03.AS2 (VCC), AB03.AT2 (VCC), AB03.AU2 (VCC), AB03.AV2 (VCC), AB03.BD2 (VCC), AB03.BE2 (VCC), AB03.BF2 (VCC), AB03.BH2 (VCC), AB03.BJ2 (VCC), B21.A2 (VCC), B22.A2 (VCC), B23.A2 (VCC), B24.A2 (VCC), B30.A2 (VCC), C12.A2 (VCC), C39.A2 (VCC), D07.A2 (VCC), D08.A2 (VCC), D39.A2 (VCC), E09.A2 (VCC); also elsewhere on the board
WRITE: B22.S1 (1), C39.A1, C39.E2, C39.N2
X_RW_RETURN: B39.D2, D39.F2, D39.K1; also elsewhere on the board
X_RW_SOURCE: A39.D2, C39.F2, C39.K1; also elsewhere on the board
Y_RW_RETURN: A38.D2, D39.P2, D39.S1; also elsewhere on the board
Y_RW_SOURCE: B38.D2, C39.P2, C39.S1; also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-13 Memory Control
Power Cabling:
* Use only if mc8i is installed.

Schematic: pdp8i-dec.sch, sheet 18

Parts:
A30, A31, A32, A33: G021; H807
A36, A37: G228; H807
A38, A39: G624; H807
AB28, AB29, AB34, AB35: W025; H807-2
B31, B32, B33: G021; H807
B36, B37: G228; H807
B38, B39: G624; H807
H04, H05: W011; H807

Connections:
-6V: A36.K1, A36.L2, A36.S1, A36.U2, A37.L2, A38.V2, A39.V2, B36.K1, B36.L2, B36.S1, B36.U2, B37.K1, B37.L2, B37.S1, B37.U2, B38.V2, B39.V2; also elsewhere on the board
-15V: A30.B2 (-15V), A31.B2 (-15V), A32.B2 (-15V), A33.B2 (-15V), B31.B2 (-15V), B32.B2 (-15V), B33.B2 (-15V); also elsewhere on the board
-30V: A36.V2, A37.V2, B36.V2, B37.V2; also elsewhere on the board
B_FIELD: A37.N2; also elsewhere on the board
B_FIELD_: A36.E2, A36.N2, A37.E2, B36.E2, B36.N2, B37.E2, B37.N2; also elsewhere on the board
B_INHIBIT: A36.A1, A37.A1, B36.A1, B37.A1; also elsewhere on the board
B_MEM_ENABLE: A30.T2, A31.T2, A32.T2, A33.T2, B31.T2, B32.T2, B33.T2; also elsewhere on the board
GND: A30.C2 (GND), A30.T1 (GND), A31.C2 (GND), A31.T1 (GND), A32.C2 (GND), A32.T1 (GND), A33.C2 (GND), A33.T1 (GND), A36.C2 (GND), A36.T1 (GND), A37.C2 (GND), A37.T1 (GND), A38.C2, A39.C2, B31.C2 (GND), B31.T1 (GND), B32.C2 (GND), B32.T1 (GND), B33.C2 (GND), B33.T1 (GND), B36.C2 (GND), B36.T1 (GND), B37.C2 (GND), B37.T1 (GND), B38.C2, B39.C2, H04.C2 (GND), H04.F2 (GND), H04.J2 (GND), H04.L2 (GND), H04.N2 (GND), H04.R2 (GND), H04.U2 (GND), H05.C2 (GND), H05.F2 (GND), H05.J2 (GND), H05.L2 (GND), H05.N2 (GND), H05.R2 (GND), H05.U2 (GND); also elsewhere on the board
MB00_: A36.D2; also elsewhere on the board
MB01_: A36.D1; also elsewhere on the board
MB02_: A36.M2; also elsewhere on the board
MB03_: A36.L1; also elsewhere on the board
MB04_: B36.D2; also elsewhere on the board
MB05_: B36.D1; also elsewhere on the board
MB06_: B36.M2; also elsewhere on the board
MB07_: B36.L1; also elsewhere on the board
MB08_: B37.D2; also elsewhere on the board
MB09_: B37.D1; also elsewhere on the board
MB10_: B37.M2; also elsewhere on the board
MB11_: B37.L1; also elsewhere on the board
MB_PARITY_ODD: A37.D2, A37.M2; also elsewhere on the board
MEM00: A31.A1, H04.E2; also elsewhere on the board
MEM01: A31.U2, H04.H2; also elsewhere on the board
MEM02: A32.A1, H04.K2; also elsewhere on the board
MEM03: A32.U2, H04.M2; also elsewhere on the board
MEM04: A33.A1, H04.P2; also elsewhere on the board
MEM05: A33.U2, H04.S2; also elsewhere on the board
MEM06: B31.A1, H04.T2; also elsewhere on the board
MEM07: B31.U2, H04.V2; also elsewhere on the board
MEM08: B32.A1, H05.D2; also elsewhere on the board
MEM09: B32.U2, H05.E2; also elsewhere on the board
MEM10: B33.A1, H05.H2; also elsewhere on the board
MEM11: B33.U2, H05.K2; also elsewhere on the board
MEM_BEGIN_: A30.B1, A31.B1, A32.B1, A33.B1, B31.B1, B32.B1, B33.B1; also elsewhere on the board
MEM_P: A30.A1, H04.D2; also elsewhere on the board
unnamed: A36.F2, A38.N2
unnamed: A36.H2 (H), A38.P2
unnamed: A36.F1 (H), A38.R2
unnamed: A36.E1, A38.M2
unnamed: A36.R2 (H), A38.S2
unnamed: A36.P2, A38.L2
unnamed: A36.N1 (H), A38.T2
unnamed: A36.M1, A38.K2
unnamed: A37.H2 (H), A39.P2
unnamed: A37.F2, A39.N2
unnamed: B36.E1, B38.M2
unnamed: B36.P2, B38.L2
unnamed: B36.M1, B38.K2
unnamed: B36.F2, B38.N2
unnamed: B36.N1 (H), B38.T2
unnamed: B36.R2 (H), B38.S2
unnamed: B36.F1 (H), B38.R2
unnamed: B36.H2 (H), B38.P2
unnamed: B37.F2, B39.N2
unnamed: B37.E1, B39.M2
unnamed: B37.P2, B39.L2
unnamed: B37.M1, B39.K2
unnamed: B37.H2 (H), B39.P2
unnamed: B37.N1 (H), B39.T2
unnamed: B37.R2 (H), B39.S2
unnamed: B37.F1 (H), B39.R2
unnamed: A37.J2 (J), AB35.AS2
unnamed: A37.K2 (K), AB35.AT2
unnamed: A36.J2 (J), AB35.AC2
unnamed: A36.K2 (K), AB35.AD2
unnamed: A36.H1 (J), AB35.AE2
unnamed: A36.J1 (K), AB35.AF2
unnamed: A36.S2 (J), AB35.AH2
unnamed: A36.T2 (K), AB35.AJ2
unnamed: A36.P1 (J), AB35.AK2
unnamed: A36.R1 (K), AB35.AL2
unnamed: AB35.AM2, B36.J2 (J)
unnamed: AB35.AN2, B36.K2 (K)
unnamed: AB35.AP2, B36.H1 (J)
unnamed: AB35.AR2, B36.J1 (K)
unnamed: AB35.BR2, B37.R1 (K)
unnamed: AB35.BP2, B37.P1 (J)
unnamed: AB35.BN2, B37.T2 (K)
unnamed: AB35.BM2, B37.S2 (J)
unnamed: AB35.BL2, B37.J1 (K)
unnamed: AB35.BK2, B37.H1 (J)
unnamed: AB35.BJ2, B37.K2 (K)
unnamed: AB35.BH2, B37.J2 (J)
unnamed: AB35.BF2, B36.R1 (K)
unnamed: AB35.BE2, B36.P1 (J)
unnamed: AB35.BC2, B36.S2 (J)
unnamed: AB35.BD2, B36.T2 (K)
unnamed: A30.D2, AB34.AS2
unnamed: A30.E2, AB34.AT2
unnamed: A31.D2, AB34.AC2
unnamed: A31.E2, AB34.AD2
unnamed: A31.L1, AB34.AE2
unnamed: A31.M1, AB34.AF2
unnamed: A32.D2, AB34.AH2
unnamed: A32.E2, AB34.AJ2
unnamed: A32.L1, AB34.AK2
unnamed: A32.M1, AB34.AL2
unnamed: A33.D2, AB34.AM2
unnamed: A33.E2, AB34.AN2
unnamed: A33.L1, AB34.AP2
unnamed: A33.M1, AB34.AR2
unnamed: A30.L1, AB29.AS2
unnamed: A30.M1, AB29.AT2
unnamed: A31.F2, AB29.AC2
unnamed: A31.H2, AB29.AD2
unnamed: A31.N1, AB29.AE2
unnamed: A31.P1, AB29.AF2
unnamed: A32.F2, AB29.AH2
unnamed: A32.H2, AB29.AJ2
unnamed: A32.N1, AB29.AK2
unnamed: A32.P1, AB29.AL2
unnamed: A33.F2, AB29.AM2
unnamed: A33.H2, AB29.AN2
unnamed: A33.N1, AB29.AP2
unnamed: A33.P1, AB29.AR2
unnamed: AB34.BP2, B33.L1
unnamed: AB34.BR2, B33.M1
unnamed: AB34.BM2, B33.D2
unnamed: AB34.BN2, B33.E2
unnamed: AB34.BK2, B32.L1
unnamed: AB34.BL2, B32.M1
unnamed: AB34.BJ2, B32.E2
unnamed: AB34.BH2, B32.D2
unnamed: AB34.BC2, B31.D2
unnamed: AB34.BD2, B31.E2
unnamed: AB34.BE2, B31.L1
unnamed: AB34.BF2, B31.M1
unnamed: AB29.BC2, B31.F2
unnamed: AB29.BD2, B31.H2
unnamed: AB29.BE2, B31.N1
unnamed: AB29.BF2, B31.P1
unnamed: AB29.BH2, B32.F2
unnamed: AB29.BJ2, B32.H2
unnamed: AB29.BK2, B32.N1
unnamed: AB29.BL2, B32.P1
unnamed: AB29.BM2, B33.F2
unnamed: AB29.BN2, B33.H2
unnamed: AB29.BP2, B33.N1
unnamed: AB29.BR2, B33.P1
unnamed: A37.P2, A39.L2
unnamed: A37.R2 (H), A39.S2
unnamed: A37.S2 (J), AB28.AS2
unnamed: A37.T2 (K), AB28.AT2
SLICE: A30.S2, A31.S2, A32.S2, A33.S2, B31.S2, B32.S2, B33.S2
STROBE_FIELD0: A30.D1, A31.D1, A32.D1, A33.D1, B31.D1, B32.D1, B33.D1; also elsewhere on the board
STROBE_FIELD1: A30.R1, A31.R1, A32.R1, A33.R1, B31.R1, B32.R1, B33.R1; also elsewhere on the board
VCC: A30.A2 (VCC), A31.A2 (VCC), A32.A2 (VCC), A33.A2 (VCC), A36.A2 (VCC), A37.A2 (VCC), B31.A2 (VCC), B32.A2 (VCC), B33.A2 (VCC), B36.A2 (VCC), B37.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-14 Sense Amps and Inhibit Drivers
MEMORY_SUPPLY+
Moved here from D-BS-mc8i-0-2
* Use G020 instead of G021 if mc8i is not installed.
** Use only with mp8i option.

Schematic: pdp8i-dec.sch, sheet 19

Parts:
C35: H807
C37, C38: G221; H807
CD34: G610; H807-2
CD36: G611; H807-2
D32, D33: G221; H807
D35: H807

Connections:
BB_FIELD_: D32.D2, D33.D2; also elsewhere on the board
B_FIELD_: C37.D2, C38.D2; also elsewhere on the board
C23J2: C38.J2, CD36.AN2 (N2)
C23K2: C38.K2, CD36.AM2 (M2)
C23L2: C38.L2, CD36.AR2 (R2)
C23M2: C38.M2, CD36.AP2 (P2)
C23N2: C38.N2, CD36.AT2 (T2)
C23P2: C38.P2, CD36.AS2 (S2)
C23R2: C38.R2, CD36.AV2 (V2)
C23S2: C38.S2, CD36.AU2 (U2)
C24J2: C37.J2, CD36.AD2 (D2)
C24K2: C37.K2, CD36.AC2 (C2)
C24M2: C37.M2, CD36.AE2 (E2)
C24N2: C37.N2, CD36.AJ2 (J2)
C24P2: C37.P2, CD36.AH2 (H2)
C24R2: C37.R2, CD36.AL2 (L2)
C24S2: C37.S2, CD36.AK2 (K2)
D18J2: CD34.BK2 (K2), D32.J2
D18K2: CD34.BL2 (L2), D32.K2
D18L2: CD34.BH2 (H2), D32.L2
D18M2: CD34.BJ2 (J2), D32.M2
D18N2: CD34.BE2 (E2), D32.N2
D18P2: CD34.BF2 (F2), D32.P2
D18R2: CD34.BC2 (C2), D32.R2
D18S2: CD34.BD2 (D2), D32.S2
D19J2: CD34.BU2 (U2), D33.J2
D19K2: CD34.BV2 (V2), D33.K2
D19L2: CD34.BS2 (S2), D33.L2
D19M2: CD34.BT2 (T2), D33.M2
D19N2: CD34.BP2 (P2), D33.N2
D19P2: CD34.BR2 (R2), D33.P2
D19R2: CD34.BM2 (M2), D33.R2
D19S2: CD34.BN2 (N2), D33.S2
GND: C37.C2 (GND), C38.C2 (GND), D32.C2 (GND), D33.C2 (GND); also elsewhere on the board
MA00: C38.E2; also elsewhere on the board
MA00_: C37.E2; also elsewhere on the board
MA01: C37.H2, C38.H2; also elsewhere on the board
MA02: C37.F2, C38.F2; also elsewhere on the board
MA03: D33.E2; also elsewhere on the board
MA03_: D32.E2; also elsewhere on the board
MA04: D32.H2, D33.H2; also elsewhere on the board
MA05: D32.F2, D33.F2; also elsewhere on the board
NEG_CLAMP: C37.V2, C38.V2, D32.V2, D33.V2; also elsewhere on the board
V24L2: C37.L2, CD36.AF2 (F2)
VCC: C37.A2 (VCC), C38.A2 (VCC), D32.A2 (VCC), D33.A2 (VCC); also elsewhere on the board
X_RW_RETURN: D32.T2, D33.T2; also elsewhere on the board
X_RW_SOURCE: C37.T2, C38.T2; also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-15 X Axis Selection
Core Memory:
* G611 in CD36 is replaced with G612 for MP8i.

Schematic: pdp8i-dec.sch, sheet 20

Parts:
C32, C33: G221; H807
CD34: G610; H807-2
CD36: G611; H807-2
D37, D38: G221; H807

Connections:
BB_FIELD_: C32.D2, C33.D2; also elsewhere on the board
B_FIELD_: D37.D2, D38.D2; also elsewhere on the board
C23J1: C33.J2, CD34.AN2 (N2)
C23K1: C33.K2, CD34.AM2 (M2)
C23L1: C33.L2, CD34.AR2 (R2)
C23M1: C33.M2, CD34.AP2 (P2)
C23N1: C33.N2, CD34.AT2 (T2)
C23P1: C33.P2, CD34.AS2 (S2)
C23R1: C33.R2, CD34.AV2 (V2)
C23S1: C33.S2, CD34.AU2 (U2)
C24J1: C32.J2, CD34.AD2 (D2)
C24K1: C32.K2, CD34.AC2 (C2)
C24M1: C32.M2, CD34.AE2 (E2)
C24N1: C32.N2, CD34.AJ2 (J2)
C24P1: C32.P2, CD34.AH2 (H2)
C24R1: C32.R2, CD34.AL2 (L2)
C24S1: C32.S2, CD34.AK2 (K2)
D18J1: CD36.BK2 (K2), D37.J2
D18K1: CD36.BL2 (L2), D37.K2
D18L1: CD36.BH2 (H2), D37.L2
D18M1: CD36.BJ2 (J2), D37.M2
D18N1: CD36.BE2 (E2), D37.N2
D18P1: CD36.BF2 (F2), D37.P2
D18R1: CD36.BC2 (C2), D37.R2
D18S1: CD36.BD2 (D2), D37.S2
D19J1: CD36.BU2 (U2), D38.J2
D19K1: CD36.BV2 (V2), D38.K2
D19L1: CD36.BS2 (S2), D38.L2
D19M1: CD36.BT2 (T2), D38.M2
D19N1: CD36.BP2 (P2), D38.N2
D19P1: CD36.BR2 (R2), D38.P2
D19R1: CD36.BM2 (M2), D38.R2
D19S1: CD36.BN2 (N2), D38.S2
GND: C32.C2 (GND), C33.C2 (GND), D37.C2 (GND), D38.C2 (GND); also elsewhere on the board
MA06: C33.E2; also elsewhere on the board
MA06_: C32.E2; also elsewhere on the board
MA07: C32.H2, C33.H2; also elsewhere on the board
MA08: C32.F2, C33.F2; also elsewhere on the board
MA09: D38.E2; also elsewhere on the board
MA09_: D37.E2; also elsewhere on the board
MA10: D37.H2, D38.H2; also elsewhere on the board
MA11: D37.F2, D38.F2; also elsewhere on the board
NEG_CLAMP: C32.V2, C33.V2, D37.V2, D38.V2; also elsewhere on the board
V24L1: C32.L2, CD34.AF2 (F2)
VCC: C32.A2 (VCC), C33.A2 (VCC), D37.A2 (VCC), D38.A2 (VCC); also elsewhere on the board
Y_RW_RETURN: D37.T2, D38.T2; also elsewhere on the board
Y_RW_SOURCE: C32.T2, C33.T2; also elsewhere on the board

Notes on the sheet:
D-BS-8i-0-16 Y Axis Selection
Core Memory:
* G611 in CD36 is replaced with G612 for MP8i.
C35
D35
