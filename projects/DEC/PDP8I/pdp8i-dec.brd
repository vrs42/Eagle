# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8I/pdp8i-dec.brd (continued)

Schematic: pdp8i-dec.sch, sheet 21

Parts:
A13, A16, A19: M113; H807
B10: M720; H807
B11, B18, B19: M216; H807
B12, B13, B14, B15, B16: M617; H807
B20: M115; H807
B21: M113; H807
E12: M113; H807
H01, H02, H03: W011; H807

Connections:
+3V(04): A19.D1 (IN1), A19.D2 (IN1), A19.L2 (IN1); also elsewhere on the board
+3V(08): B11.A1 (R), B12.B1 (IN2), B12.C1 (IN3), B12.D1 (IN4), B12.E2 (IN2), B12.F2 (IN3), B12.H1 (IN2), B12.H2 (IN4), B12.J1 (IN3), B12.K1 (IN4); also elsewhere on the board
+3V(09): B12.L2 (IN2), B12.M2 (IN3), B12.N1 (IN2), B12.N2 (IN4), B12.P1 (IN3), B12.R1 (IN4); also elsewhere on the board
+3V(10): B12.S2 (IN2), B12.T2 (IN3), B12.U2 (IN4), B13.B1 (IN2), B13.C1 (IN3), B13.D1 (IN4), B13.E2 (IN2), B13.F2 (IN3), B13.H2 (IN4); also elsewhere on the board
+3V(11): A13.U1, B13.H1 (IN2), B13.J1 (IN3), B13.K1 (IN4)
+3V(12): B13.L2 (IN2), B13.M2 (IN3), B13.N1 (IN2), B13.N2 (IN4), B13.P1 (IN3), B13.R1 (IN4), B13.S2 (IN2), B13.T2 (IN3), B13.U1, B13.U2 (IN4), B14.B1 (IN2), B14.C1 (IN3), B14.D1 (IN4)
+3V(13): B13.V1, B14.E2 (IN2), B14.F2 (IN3), B14.H2 (IN4)
+3V(14): B14.H1 (IN2), B14.J1 (IN3), B14.K1 (IN4), B14.L2 (IN2), B14.M2 (IN3), B14.N1 (IN2), B14.N2 (IN4), B14.P1 (IN3), B14.R1 (IN4), B14.U1
+3V(15): B14.S2 (IN2), B14.T2 (IN3), B14.U2 (IN4), B14.V1, B15.B1 (IN2), B15.C1 (IN3), B15.D1 (IN4)
+3V(16): B15.E2 (IN2), B15.F2 (IN3), B15.H1 (IN2), B15.H2 (IN4), B15.J1 (IN3), B15.K1 (IN4), B15.U1
+3V(17): B15.L2 (IN2), B15.M2 (IN3), B15.N1 (IN2), B15.N2 (IN4), B15.P1 (IN3), B15.R1 (IN4), B15.S2 (IN2), B15.T2 (IN3), B15.U2 (IN4), B16.V1
+3V(18): B16.D1 (IN4), B16.H2 (IN4), B16.K1 (IN4), B16.N1 (IN2), B16.P1 (IN3), B16.R1 (IN4), B16.S2 (IN2), B16.T2 (IN3), B16.U1, B16.U2 (IN4)
+3V(19): A19.U1, B18.K2 (R); also elsewhere on the board
+3V(20): A19.V1, B18.N2 (S), B18.R1 (S), B18.U2 (S), B19.A1 (R), B19.D1 (S), B19.F2 (S), B19.K1 (S), B19.K2 (R), B19.N2 (S), B19.R1 (S), B19.U2 (S)
BF0: A16.E2 (IN2), B18.P2 (1)
BF1: A16.M1 (IN2), B18.S1 (1)
BF2: A16.R2 (IN2), B18.V2 (1)
BF_ENABLE: A16.D2 (IN1), A16.L1 (IN1), A16.P2 (IN1), B11.M1 (0)
BMA00: B14.E1 (OUT), H01.K2
BMA01: B14.J2 (OUT), H01.M2
BMA02: B14.L1 (OUT), H01.P2
BMA03: B14.P2 (OUT), H01.S2
BMA04: B14.S1 (OUT), H01.T2
BMA05: B14.V2 (OUT), H01.V2
BMA06: B15.E1 (OUT), H02.D2
BMA07: B15.J2 (OUT), H02.E2
BMA08: B15.L1 (OUT), H02.H2
BMA09: B15.P2 (OUT), H02.K2
BMA10: B15.S1 (OUT), H02.M2
BMA11: B15.V2 (OUT), H02.P2
B_SET: A19.E2 (IN2), A19.M1 (IN2); also elsewhere on the board
B_SET_: A19.F2 (OUT), B11.J1 (D), B20.F2 (IN3)
CLEAR_DF_: B21.S2 (OUT); also elsewhere on the board
CLEAR_IB_: B21.N2 (OUT); also elsewhere on the board
CLEAR_IFDFBF_: B21.L2 (IN1), B21.P1 (IN1), B21.P2 (IN1); also elsewhere on the board
CLEAR_IF_: B21.S1 (OUT); also elsewhere on the board
DEFER: B20.C1 (IN3); also elsewhere on the board
DF0: A16.E1 (IN2), B19.M2 (D); also elsewhere on the board
DF1: A16.J2 (IN2), B19.P1 (D); also elsewhere on the board
DF2: A16.R1 (IN2), B19.T2 (D); also elsewhere on the board
DF_ENABLE: A16.D1 (IN1), A16.H2 (IN1), A16.P1 (IN1), B11.J2 (0)
DF_ENABLE_: B11.E2 (D), B20.D1 (OUT), B20.D2 (IN1)
EA0: B16.E1 (OUT), B16.M1 (IN1), H01.D2
EA0_: B16.S1 (OUT); also elsewhere on the board
EA1: B16.J2 (OUT), B16.R2 (IN1), H01.E2
EA1_: B16.V2 (OUT); also elsewhere on the board
EA2: B16.L1 (OUT), H01.H2; also elsewhere on the board
EXT_DATA_ADD0: B18.M2 (D); also elsewhere on the board
EXT_DATA_ADD1: B18.P1 (D); also elsewhere on the board
EXT_DATA_ADD2: B18.T2 (D); also elsewhere on the board
GND: A13.C2 (GND), A13.T1 (GND), A16.C2 (GND), A16.T1 (GND), A19.C2 (GND), A19.T1 (GND), B10.C2 (GND), B11.C2 (GND), B11.T1 (GND), B12.C2 (GND), B12.T1 (GND), B13.C2 (GND), B13.T1 (GND), B14.C2 (GND), B14.T1 (GND), B15.C2 (GND), B15.T1 (GND), B16.C2 (GND), B16.T1 (GND), B18.C2 (GND), B18.T1 (GND), B19.C2 (GND), B19.T1 (GND), B20.C2 (GND), B20.T1 (GND), B21.C2 (GND), B21.T1 (GND), E12.C2 (GND), E12.T1 (GND), H01.C2 (GND), H01.F2 (GND), H01.J2 (GND), H01.L2 (GND), H01.N2 (GND), H01.R2 (GND), H01.U2 (GND), H02.C2 (GND), H02.F2 (GND), H02.J2 (GND), H02.L2 (GND), H02.N2 (GND), H02.R2 (GND), H02.U2 (GND), H03.C2 (GND), H03.F2 (GND), H03.J2 (GND), H03.L2 (GND), H03.N2 (GND), H03.R2 (GND), H03.U2 (GND); also elsewhere on the board
IF0: A16.B1 (IN2), B19.C1 (D); also elsewhere on the board
IF1: A16.J1 (IN2), B19.E2 (D); also elsewhere on the board
IF2: A16.M2 (IN2), B19.J1 (D); also elsewhere on the board
IF_ENABLE: A16.A1 (IN1), A16.H1 (IN1), A16.L2 (IN1), B11.F1 (0)
IF_ENABLE_: B11.C1 (D), B20.H2 (OUT)
IF_TO_SF: A19.S1 (OUT), B19.B1 (C), B19.D2 (C), B21.M2 (IN2), B21.R1 (IN2), B21.R2 (IN2); also elsewhere on the board
JMP_: B20.A1 (IN1); also elsewhere on the board
JMS_: B20.B1 (IN2); also elsewhere on the board
KEY_STEXDP: A19.H2 (IN1); also elsewhere on the board
LOAD_BF: A19.N2 (OUT), B18.L2 (C), B18.N1 (C), B18.S2 (C)
LOAD_SF_: A19.R1 (IN2), A19.R2 (IN2); also elsewhere on the board
MA00_: B14.A1 (IN1); also elsewhere on the board
MA01_: B14.D2 (IN1); also elsewhere on the board
MA02_: B14.F1 (IN1); also elsewhere on the board
MA03_: B14.K2 (IN1); also elsewhere on the board
MA04_: B14.M1 (IN1); also elsewhere on the board
MA05_: B14.R2 (IN1); also elsewhere on the board
MA06_: B15.A1 (IN1); also elsewhere on the board
MA07_: B15.D2 (IN1); also elsewhere on the board
MA08_: B15.F1 (IN1); also elsewhere on the board
MA09_: B15.K2 (IN1); also elsewhere on the board
MA10_: B15.M1 (IN1); also elsewhere on the board
MA11_: B15.R2 (IN1); also elsewhere on the board
MANUAL_PRESET_: B11.D1 (S), B11.F2 (S), B11.K1 (S); also elsewhere on the board
MB00: B12.A1 (IN1); also elsewhere on the board
MB01: B12.D2 (IN1); also elsewhere on the board
MB02: B12.F1 (IN1); also elsewhere on the board
MB03: B12.K2 (IN1); also elsewhere on the board
MB04: B12.M1 (IN1); also elsewhere on the board
MB05: B12.R2 (IN1); also elsewhere on the board
MB06: B13.A1 (IN1); also elsewhere on the board
MB07: B13.D2 (IN1); also elsewhere on the board
MB08: B13.F1 (IN1); also elsewhere on the board
MB09: B13.K2 (IN1); also elsewhere on the board
MB10: B13.M1 (IN1); also elsewhere on the board
MB11: B13.R2 (IN1); also elsewhere on the board
MCBMB00_: B12.E1 (OUT), H02.S2
MCBMB01_: B12.J2 (OUT), H02.T2
MCBMB02_: B12.L1 (OUT), H02.V2
MCBMB03_: B12.P2 (OUT), H03.D2
MCBMB04_: B12.S1 (OUT), H03.E2
MCBMB05_: B12.V2 (OUT), H03.H2
MCBMB06_: B13.E1 (OUT), H03.K2
MCBMB07_: B13.J2 (OUT), H03.M2
MCBMB08_: B13.L1 (OUT), H03.P2
MCBMB09_: B13.P2 (OUT), H03.S2
MCBMB10_: B13.S1 (OUT), H03.T2
MCBMB11_: B13.V2 (OUT), H03.V2
MEM_DONE_: B10.D2; also elsewhere on the board
MFTP1: A19.J2 (IN2), E12.M2 (IN2); also elsewhere on the board
unnamed: A19.P1 (IN1), A19.P2 (IN1), E12.N2 (OUT)
unnamed: A19.C1 (OUT), A19.E1 (IN2)
unnamed: A19.S2 (OUT), B19.H1 (C), B19.L2 (C), B19.N1 (C), B19.S2 (C)
unnamed: A19.F1 (OUT), B20.E2 (IN2)
unnamed: A19.M2 (IN2), A19.N1 (OUT)
unnamed: A19.H1 (IN1), A19.K2 (OUT)
unnamed: A16.F2 (OUT), B16.C1 (IN3)
unnamed: A16.F1 (OUT), B16.B1 (IN2)
unnamed: A16.C1 (OUT), B16.A1 (IN1)
unnamed: A19.K1 (OUT), B11.B1 (C), B11.D2 (C), B11.H1 (C)
unnamed: A16.K1 (OUT), B16.D2 (IN1)
unnamed: A16.K2 (OUT), B16.E2 (IN2)
unnamed: A16.N1 (OUT), B16.F2 (IN3)
unnamed: A16.N2 (OUT), B16.F1 (IN1)
unnamed: A16.S1 (OUT), B16.H1 (IN2)
unnamed: A16.S2 (OUT), B16.J1 (IN3)
RESTART: E12.L2 (IN1); also elsewhere on the board
RUN: B10.J2; also elsewhere on the board
SF0: B19.E1 (1); also elsewhere on the board
SF1: B19.H2 (1); also elsewhere on the board
SF2: B19.L1 (1); also elsewhere on the board
SF3: B19.P2 (1); also elsewhere on the board
SF4: B19.S1 (1); also elsewhere on the board
SF5: B19.V2 (1); also elsewhere on the board
STROBE_: B10.E2; also elsewhere on the board
TP3: A19.L1 (IN1), B10.V2; also elsewhere on the board
TS4_: A19.J1 (IN2); also elsewhere on the board
VCC: A13.A2 (VCC), A16.A2 (VCC), A19.A2 (VCC), B10.A2 (VCC), B11.A2 (VCC), B12.A2 (VCC), B13.A2 (VCC), B14.A2 (VCC), B15.A2 (VCC), B16.A2 (VCC), B18.A2 (VCC), B19.A2 (VCC), B20.A2 (VCC), B21.A2 (VCC), E12.A2 (VCC); also elsewhere on the board
WC_SET_: A19.A1 (IN1); also elsewhere on the board
WORD_COUNT_: A19.B1 (IN2); also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-1 Memory Extension Control (1/2)

Schematic: pdp8i-dec.sch, sheet 22

Parts:
A06, A11, A12, A13, A14, A15, A16, A17, A18, A19: M113; H807
A20: M115; H807
A40: W077; H807
B16: M617; H807
B17, B18: M216; H807
B20: M115; H807
C12: M617; H807
C40: M900; H807
F09: M119; H807
F11: M117; H807

Connections:
+3V(01): A13.E1 (IN2), A13.H1 (IN1), A13.M1 (IN2), A13.R1 (IN2), A15.U1
+3V(02): A13.U2 (IN2), A14.B1 (IN2), A14.H2 (IN1), A14.J1 (IN2), A14.L1 (IN1), A15.V1
+3V(03): A14.L2 (IN1), A14.P1 (IN1), A15.B1 (IN2), A15.M2 (IN2), A15.P1 (IN1), A18.U1
+3V(04): A18.V1, A19.T2 (IN1); also elsewhere on the board
+3V(08): C12.V1; also elsewhere on the board
+3V(09): A11.V1; also elsewhere on the board
+3V(10): F09.V1; also elsewhere on the board
+3V(19): B17.D1 (S), B17.F2 (S), B17.K1 (S), B17.N2 (S), B17.R1 (S), B17.U2 (S), B18.D1 (S), B18.F2 (S), B18.K1 (S); also elsewhere on the board
+3V(66): A06.R2 (IN2), A11.U1; also elsewhere on the board
+3V(67): A06.M1 (IN2), A06.M2 (IN2), A06.V1; also elsewhere on the board
+3V(68): F09.H2 (IN8), F09.U1; also elsewhere on the board
B_EXT_INST: A06.N1 (OUT), A20.K1 (IN1), A20.N2 (IN1), A20.P1 (IN1); also elsewhere on the board
B_FETCH: B16.K2 (IN1), F09.A1 (IN1); also elsewhere on the board
CLEAR_DF_: B18.A1 (R); also elsewhere on the board
CLEAR_IB_: B17.K2 (R); also elsewhere on the board
CLEAR_IF_: B17.A1 (R); also elsewhere on the board
CUF_: F11.F2 (IN3), F11.H2 (IN4); also elsewhere on the board
DF0: A11.E1 (IN2), B18.E1 (1); also elsewhere on the board
DF0_: B18.F1 (0), C40.J2
DF1: A11.J2 (IN2), B18.H2 (1); also elsewhere on the board
DF1_: B18.J2 (0), C40.S1
DF2: A11.R1 (IN2), B18.L1 (1); also elsewhere on the board
DF2_: B18.M1 (0), C40.P2
DFSR0: A12.E1 (IN2), A40.D2
DFSR1: A12.J2 (IN2), A40.E2
DFSR2: A12.R1 (IN2), A40.F2
EXT_GO: A12.A1 (IN1), A13.F1 (OUT), A15.H2 (IN1), A17.U2 (IN2); also elsewhere on the board
EXT_INST: A14.K2 (OUT), A15.U2 (IN2)
E_SET_: A16.U2 (IN2); also elsewhere on the board
F_SET_: A16.T2 (IN1); also elsewhere on the board
GND: A06.C2 (GND), A06.T1 (GND), A11.C2 (GND), A11.T1 (GND), A12.C2 (GND), A12.T1 (GND), A13.C2 (GND), A13.T1 (GND), A14.C2 (GND), A14.T1 (GND), A15.C2 (GND), A15.T1 (GND), A16.C2 (GND), A16.T1 (GND), A17.C2 (GND), A17.T1 (GND), A18.C2 (GND), A18.T1 (GND), A19.C2 (GND), A19.T1 (GND), A20.C2 (GND), A20.T1 (GND), B16.C2 (GND), B16.T1 (GND), B17.C2 (GND), B17.T1 (GND), B18.C2 (GND), B18.T1 (GND), B20.C2 (GND), B20.T1 (GND), C12.C2 (GND), C12.T1 (GND), F09.C2 (GND), F09.T1 (GND), F11.C2 (GND), F11.T1 (GND); also elsewhere on the board
IB0: A17.J1 (IN2), B17.P2 (1)
IB1: A17.M1 (IN2), B17.S1 (1)
IB2: A17.R1 (IN2), B17.V2 (1)
IB_TO_IF: A15.A1 (IN1), A17.C1 (OUT), B17.B1 (C), B17.D2 (C), B17.H1 (C); also elsewhere on the board
IF0: A11.J1 (IN2), B17.E1 (1); also elsewhere on the board
IF0_: B17.F1 (0), C40.N1
IF1: A11.M2 (IN2), B17.H2 (1); also elsewhere on the board
IF1_: B17.J2 (0), C40.C1
IF2: A11.U2 (IN2), B17.L1 (1); also elsewhere on the board
IF2_: B17.M1 (0), C40.D1
IFSR0: A18.E1 (IN2), A40.H2
IFSR1: A18.J2 (IN2), A40.J2
IFSR2: A18.R1 (IN2), A40.K2
INT_INHIBIT: A15.E1 (IN2), F11.J2 (OUT)
INT_INHIBIT_: A15.F1 (OUT), F11.D2 (IN1); also elsewhere on the board
IOT: A14.E1 (IN2), C12.F2 (IN3), C12.H2 (IN4), F09.F2 (IN7); also elsewhere on the board
JMP_: A17.D1 (IN1); also elsewhere on the board
JMS_: A17.E1 (IN2); also elsewhere on the board
KEY_LAMFTS0_: A17.H1 (IN1), A17.L1 (IN1), A17.P1 (IN1), A19.U2 (IN2); also elsewhere on the board
LOAD_IB: A18.C1 (OUT), B17.L2 (C), B17.N1 (C), B17.S2 (C)
MB03_: B16.L2 (IN2), F09.B1 (IN2); also elsewhere on the board
MB04: B16.M2 (IN3), F09.C1 (IN3); also elsewhere on the board
MB05_: B16.N2 (IN4), F09.D1 (IN4); also elsewhere on the board
MB06: A12.E2 (IN2), A15.T2 (IN1), A18.E2 (IN2); also elsewhere on the board
MB06XMB09: A06.N2 (OUT), A06.U2 (IN2); also elsewhere on the board
MB06_: F09.D2 (IN5); also elsewhere on the board
MB07: A12.M1 (IN2), A18.M1 (IN2), A20.R1 (IN2), A20.R2 (IN3); also elsewhere on the board
MB07_: A06.P1 (IN1), A20.L1 (IN2); also elsewhere on the board
MB08: A12.R2 (IN2), A18.R2 (IN2), A20.M1 (IN3), A20.P2 (IN2); also elsewhere on the board
MB08_: A06.R1 (IN2), A20.S1 (IN3); also elsewhere on the board
MB09: A14.D2 (IN1), F09.E2 (IN6); also elsewhere on the board
MB10: A12.B1 (IN2), A15.P2 (IN1); also elsewhere on the board
MB10_: A15.L1 (IN1); also elsewhere on the board
MB11: A11.B1 (IN2); also elsewhere on the board
MB11_: A13.A1 (IN1); also elsewhere on the board
MB_TO_IB: A15.S1 (OUT), A18.D2 (IN1), A18.L1 (IN1), A18.P2 (IN1)
ME06_: A13.N1 (OUT); also elsewhere on the board
ME07_: A13.S1 (OUT); also elsewhere on the board
ME08_: A13.V2 (OUT); also elsewhere on the board
ME09_: A13.K2 (OUT); also elsewhere on the board
ME10_: A13.N2 (OUT); also elsewhere on the board
ME11_: A13.S2 (OUT); also elsewhere on the board
MEM_EXT: A11.A1 (IN1), A13.E2 (IN2), A14.E2 (IN2), A14.K1 (OUT), A15.R2 (IN2)
MEM_EXT_: A14.F1 (OUT), A14.H1 (IN1); also elsewhere on the board
MEM_EXT_AC_LOAD_ENABLE_: A14.S2 (OUT); also elsewhere on the board
MEM_EXT_IO_ENABLE_: C12.J2 (OUT); also elsewhere on the board
unnamed: A06.P2 (IN1), A06.S1 (OUT)
unnamed: A06.L2 (IN1), A15.V2 (OUT)
unnamed: A06.S2 (OUT), A06.T2 (IN1)
unnamed: A15.R1 (IN2), A15.S2 (OUT)
unnamed: A15.J2 (IN2), A15.N1 (OUT)
unnamed: A15.J1 (IN2), A19.V2 (OUT)
unnamed: A15.K2 (OUT), A18.B1 (IN2)
unnamed: A18.F2 (OUT), B20.F1 (IN2)
unnamed: A18.K1 (OUT), B20.H1 (IN3)
unnamed: A17.D2 (IN1), A18.F1 (OUT), B20.E1 (IN1)
unnamed: A17.H2 (IN1), A18.K2 (OUT), B20.J2 (IN1)
unnamed: A18.N1 (OUT), B20.K2 (IN2)
unnamed: A18.N2 (OUT), B20.L2 (IN3)
unnamed: A17.L2 (IN1), A18.S1 (OUT), B20.K1 (IN1)
unnamed: A18.S2 (OUT), B20.L1 (IN2)
unnamed: A18.V2 (OUT), B20.M1 (IN3)
unnamed: B17.T2 (D), B20.N1 (OUT)
unnamed: B17.P1 (D), B20.M2 (OUT)
unnamed: B17.M2 (D), B20.J1 (OUT)
unnamed: A17.E2 (IN2), A17.K1 (OUT)
unnamed: A17.J2 (IN2), A17.N1 (OUT)
unnamed: A17.M2 (IN2), A17.S1 (OUT)
unnamed: A17.N2 (OUT), B17.J1 (D)
unnamed: A17.K2 (OUT), B17.E2 (D)
unnamed: A17.F2 (OUT), B17.C1 (D)
unnamed: A16.V2 (OUT), A20.A1 (IN1)
unnamed: A17.F1 (OUT), A20.C1 (IN3)
unnamed: A17.B1 (IN2), A20.D1 (OUT)
unnamed: A06.L1 (IN1), F09.J2 (OUT)
unnamed: A14.A1 (IN1), B16.P2 (OUT)
unnamed: A14.C1 (OUT), A14.D1 (IN1)
unnamed: A14.F2 (OUT), A14.J2 (IN2)
unnamed: A14.M1 (IN2), A20.N1 (OUT), A20.T2 (IN1)
unnamed: A14.M2 (IN2), A20.S2 (OUT), A20.U2 (IN2)
unnamed: A14.R1 (IN2), A20.U1 (OUT), A20.V2 (IN3)
unnamed: A14.R2 (IN2), A20.V1 (OUT), C12.D2 (IN1)
unnamed: A11.D1 (IN1), A11.H2 (IN1), A11.P1 (IN1), A14.N1 (OUT)
unnamed: A11.H1 (IN1), A11.L2 (IN1), A11.T2 (IN1), A14.S1 (OUT)
unnamed: A11.S2 (OUT), A20.K2 (IN2)
unnamed: A11.N1 (OUT), A20.F1 (IN2)
unnamed: A11.F2 (OUT), A20.E2 (IN2)
unnamed: A11.F1 (OUT), A20.D2 (IN1)
unnamed: A11.K1 (OUT), A20.F2 (IN3)
unnamed: A11.N2 (OUT), A20.H1 (IN3)
unnamed: A11.V2 (OUT), A20.L2 (IN3)
unnamed: A11.S1 (OUT), A20.J2 (IN1)
unnamed: A11.K2 (OUT), A20.E1 (IN1)
unnamed: A13.L1 (IN1), A20.H2 (OUT)
unnamed: A13.P1 (IN1), A20.J1 (OUT)
unnamed: A13.T2 (IN1), A20.M2 (OUT)
unnamed: A12.D2 (IN1), A12.L1 (IN1), A12.P2 (IN1), A13.K1 (OUT)
unnamed: A12.S2 (OUT), B20.U2 (IN2)
unnamed: A12.V2 (OUT), B20.V2 (IN3)
unnamed: A12.N2 (OUT), B20.S1 (IN3)
unnamed: A12.N1 (OUT), B20.R1 (IN2)
unnamed: A12.K2 (OUT), B20.P1 (IN1)
unnamed: A12.S1 (OUT), B20.T2 (IN1)
unnamed: A12.K1 (OUT), B20.R2 (IN3)
unnamed: A12.F2 (OUT), B20.P2 (IN2)
unnamed: A12.F1 (OUT), B20.N2 (IN1)
unnamed: B18.C1 (D), B20.S2 (OUT)
unnamed: B18.E2 (D), B20.U1 (OUT)
unnamed: B18.J1 (D), B20.V1 (OUT)
unnamed: A17.S2 (OUT), B18.B1 (C), B18.D2 (C), B18.H1 (C)
unnamed: A11.C1 (OUT), A13.J1 (IN2)
unnamed: A17.P2 (IN1), A17.V2 (OUT)
unnamed: A13.D1 (IN1), A13.F2 (OUT)
unnamed: A13.C1 (OUT), A17.T2 (IN1)
unnamed: A15.C1 (OUT), A15.D1 (IN1)
unnamed: A12.C1 (OUT), F11.E2 (IN2)
PC_LOAD: A15.H1 (IN1); also elsewhere on the board
PC_LOADXSR_ENABLE_: A15.K1 (OUT), A17.A1 (IN1), A17.R2 (IN2), A18.A1 (IN1); also elsewhere on the board
RIB: A11.D2 (IN1), A11.L1 (IN1), A11.P2 (IN1), A13.H2 (IN1), A13.L2 (IN1), A13.P2 (IN1), A14.N2 (OUT); also elsewhere on the board
RMF_: A06.V2 (OUT), A13.B1 (IN2), A15.L2 (IN1), A15.M1 (IN2); also elsewhere on the board
SF0: A11.E2 (IN2), A18.J1 (IN2); also elsewhere on the board
SF1: A11.M1 (IN2), A18.M2 (IN2); also elsewhere on the board
SF2: A11.R2 (IN2), A18.U2 (IN2); also elsewhere on the board
SF3: A12.J1 (IN2), A13.J2 (IN2); also elsewhere on the board
SF4: A12.M2 (IN2), A13.M2 (IN2); also elsewhere on the board
SF5: A12.U2 (IN2), A13.R2 (IN2); also elsewhere on the board
SF_ENABLE: A12.H1 (IN1), A12.L2 (IN1), A12.T2 (IN1), A15.N2 (OUT), A18.H1 (IN1), A18.L2 (IN1), A18.T2 (IN1); also elsewhere on the board
SR_ENABLE: A12.D1 (IN1), A12.H2 (IN1), A12.P1 (IN1), A18.D1 (IN1), A18.H2 (IN1), A18.P1 (IN1); also elsewhere on the board
TP3: A13.D2 (IN1), A14.P2 (IN1), A20.B1 (IN2); also elsewhere on the board
TS3: C12.E2 (IN2); also elsewhere on the board
VCC: A06.A2 (VCC), A11.A2 (VCC), A12.A2 (VCC), A13.A2 (VCC), A14.A2 (VCC), A15.A2 (VCC), A16.A2 (VCC), A17.A2 (VCC), A18.A2 (VCC), A19.A2 (VCC), A20.A2 (VCC), B16.A2 (VCC), B17.A2 (VCC), B18.A2 (VCC), B20.A2 (VCC), C12.A2 (VCC), F09.A2 (VCC), F11.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-1 Memory Extension Control (2/2)

Schematic: pdp8i-dec.sch, sheet 23

Parts:
A25, A26: G624; H807
A27: G228; H807
AB28: W025; H807-2
B25: G624; H807
B26, B27: G228; H807

Connections:
-6V: A25.E2, A26.E2, A27.K1, A27.L2, A27.S1, A27.U2, B25.E2, B26.K1, B26.L2, B26.S1, B26.U2, B27.K1, B27.L2, B27.S1, B27.U2; also elsewhere on the board
-30V: A27.V2, B26.V2, B27.V2; also elsewhere on the board
B_FIELD: A27.E2, A27.N2, B26.E2, B26.N2, B27.E2, B27.N2; also elsewhere on the board
B_INHIBIT: A27.A1, B26.A1, B27.A1; also elsewhere on the board
GND: A25.H2, A26.H2, A27.C2 (GND), A27.T1 (GND), B25.H2, B26.C2 (GND), B26.T1 (GND), B27.C2 (GND), B27.T1 (GND); also elsewhere on the board
MB00_: A27.D2; also elsewhere on the board
MB01_: A27.D1; also elsewhere on the board
MB02_: A27.M2; also elsewhere on the board
MB03_: A27.L1; also elsewhere on the board
MB04_: B26.D2; also elsewhere on the board
MB05_: B26.D1; also elsewhere on the board
MB06_: B26.M2; also elsewhere on the board
MB07_: B26.L1; also elsewhere on the board
MB08_: B27.D2; also elsewhere on the board
MB09_: B27.D1; also elsewhere on the board
MB10_: B27.M2; also elsewhere on the board
MB11_: B27.L1; also elsewhere on the board
unnamed: A25.P2, A27.H2 (H)
unnamed: A25.R2, A27.F1 (H)
unnamed: A25.S2, A27.R2 (H)
unnamed: A25.T2, A27.N1 (H)
unnamed: A25.N2, A27.F2
unnamed: A25.M2, A27.E1
unnamed: A25.L2, A27.P2
unnamed: A25.K2, A27.M1
unnamed: A27.J2 (J), AB28.BC2
unnamed: A27.K2 (K), AB28.BD2
unnamed: A26.P2, B26.H2 (H)
unnamed: A26.R2, B26.F1 (H)
unnamed: A26.S2, B26.R2 (H)
unnamed: A26.T2, B26.N1 (H)
unnamed: A26.N2, B26.F2
unnamed: A26.M2, B26.E1
unnamed: A26.L2, B26.P2
unnamed: A26.K2, B26.M1
unnamed: B25.P2, B27.H2 (H)
unnamed: B25.R2, B27.F1 (H)
unnamed: B25.S2, B27.R2 (H)
unnamed: B25.T2, B27.N1 (H)
unnamed: B25.N2, B27.F2
unnamed: B25.M2, B27.E1
unnamed: B25.L2, B27.P2
unnamed: B25.K2, B27.M1
unnamed: A27.H1 (J), AB28.BE2
unnamed: A27.J1 (K), AB28.BF2
unnamed: A27.S2 (J), AB28.BH2
unnamed: A27.T2 (K), AB28.BJ2
unnamed: A27.P1 (J), AB28.BK2
unnamed: A27.R1 (K), AB28.BL2
unnamed: AB28.BM2, B26.J2 (J)
unnamed: AB28.BN2, B26.K2 (K)
unnamed: AB28.BP2, B26.H1 (J)
unnamed: AB28.BR2, B26.J1 (K)
unnamed: AB28.AC2, B26.S2 (J)
unnamed: AB28.AD2, B26.T2 (K)
unnamed: AB28.AE2, B26.P1 (J)
unnamed: AB28.AF2, B26.R1 (K)
unnamed: AB28.AH2, B27.J2 (J)
unnamed: AB28.AJ2, B27.K2 (K)
unnamed: AB28.AK2, B27.H1 (J)
unnamed: AB28.AL2, B27.J1 (K)
unnamed: AB28.AM2, B27.S2 (J)
unnamed: AB28.AN2, B27.T2 (K)
unnamed: AB28.AP2, B27.P1 (J)
unnamed: AB28.AR2, B27.R1 (K)
VCC: A27.A2 (VCC), B26.A2 (VCC), B27.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-2 Inhibit Drivers
MEMORY_SUPPLY+
Memory Parity bit is handled in A37 on D-BS-8i-0-14.

Schematic: pdp8i-dec.sch, sheet 24

Parts:
C28: H807
C30, C31: G221; H807
CD27: G610; H807-2
CD29: G611; H807-2
D25, D26: G221; H807
D28: H807

Connections:
BB_FIELD: D25.D2, D26.D2; also elsewhere on the board
B_FIELD: C30.D2, C31.D2; also elsewhere on the board
C23J3: C31.J2, CD29.AN2 (N2)
C23K3: C31.K2, CD29.AM2 (M2)
C23L3: C31.L2, CD29.AR2 (R2)
C23M3: C31.M2, CD29.AP2 (P2)
C23N3: C31.N2, CD29.AT2 (T2)
C23P3: C31.P2, CD29.AS2 (S2)
C23R3: C31.R2, CD29.AV2 (V2)
C23S3: C31.S2, CD29.AU2 (U2)
C24J3: C30.J2, CD29.AD2 (D2)
C24K3: C30.K2, CD29.AC2 (C2)
C24M3: C30.M2, CD29.AE2 (E2)
C24N3: C30.N2, CD29.AJ2 (J2)
C24P3: C30.P2, CD29.AH2 (H2)
C24R3: C30.R2, CD29.AL2 (L2)
C24S3: C30.S2, CD29.AK2 (K2)
D18J3: CD27.BK2 (K2), D25.J2
D18K3: CD27.BL2 (L2), D25.K2
D18L3: CD27.BH2 (H2), D25.L2
D18M3: CD27.BJ2 (J2), D25.M2
D18N3: CD27.BE2 (E2), D25.N2
D18P3: CD27.BF2 (F2), D25.P2
D18R3: CD27.BC2 (C2), D25.R2
D18S3: CD27.BD2 (D2), D25.S2
D19J3: CD27.BU2 (U2), D26.J2
D19K3: CD27.BV2 (V2), D26.K2
D19L3: CD27.BS2 (S2), D26.L2
D19M3: CD27.BT2 (T2), D26.M2
D19N3: CD27.BP2 (P2), D26.N2
D19P3: CD27.BR2 (R2), D26.P2
D19R3: CD27.BM2 (M2), D26.R2
D19S3: CD27.BN2 (N2), D26.S2
GND: C30.C2 (GND), C31.C2 (GND), D25.C2 (GND), D26.C2 (GND); also elsewhere on the board
MA00: C31.E2; also elsewhere on the board
MA00_: C30.E2; also elsewhere on the board
MA01: C30.H2, C31.H2; also elsewhere on the board
MA02: C30.F2, C31.F2; also elsewhere on the board
MA03: D26.E2; also elsewhere on the board
MA03_: D25.E2; also elsewhere on the board
MA04: D25.H2, D26.H2; also elsewhere on the board
MA05: D25.F2, D26.F2; also elsewhere on the board
NEG_CLAMP: C30.V2, C31.V2, D25.V2, D26.V2; also elsewhere on the board
V24L3: C30.L2, CD29.AF2 (F2)
VCC: C30.A2 (VCC), C31.A2 (VCC), D25.A2 (VCC), D26.A2 (VCC); also elsewhere on the board
X_RW_RETURN: D25.T2, D26.T2; also elsewhere on the board
X_RW_SOURCE: C30.T2, C31.T2; also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-3 X Axis Selection
Core Memory:
CD27
* G611 in CD29 is replaced with G612 for MP8i.

Schematic: pdp8i-dec.sch, sheet 25

Parts:
C25, C26: G221; H807
CD27: G610; H807-2
CD29: G611; H807-2
D30, D31: G221; H807

Connections:
BB_FIELD: C25.D2, C26.D2; also elsewhere on the board
B_FIELD: D30.D2, D31.D2; also elsewhere on the board
C23J4: C26.J2, CD27.AN2 (N2)
C23K4: C26.K2, CD27.AM2 (M2)
C23L4: C26.L2, CD27.AR2 (R2)
C23M4: C26.M2, CD27.AP2 (P2)
C23N4: C26.N2, CD27.AT2 (T2)
C23P4: C26.P2, CD27.AS2 (S2)
C23R4: C26.R2, CD27.AV2 (V2)
C23S4: C26.S2, CD27.AU2 (U2)
C24J4: C25.J2, CD27.AD2 (D2)
C24K4: C25.K2, CD27.AC2 (C2)
C24M4: C25.M2, CD27.AE2 (E2)
C24N4: C25.N2, CD27.AJ2 (J2)
C24P4: C25.P2, CD27.AH2 (H2)
C24R4: C25.R2, CD27.AL2 (L2)
C24S4: C25.S2, CD27.AK2 (K2)
D18J4: CD29.BK2 (K2), D30.J2
D18K4: CD29.BL2 (L2), D30.K2
D18L4: CD29.BH2 (H2), D30.L2
D18M4: CD29.BJ2 (J2), D30.M2
D18N4: CD29.BE2 (E2), D30.N2
D18P4: CD29.BF2 (F2), D30.P2
D18R4: CD29.BC2 (C2), D30.R2
D18S4: CD29.BD2 (D2), D30.S2
D19J4: CD29.BU2 (U2), D31.J2
D19K4: CD29.BV2 (V2), D31.K2
D19L4: CD29.BS2 (S2), D31.L2
D19M4: CD29.BT2 (T2), D31.M2
D19N4: CD29.BP2 (P2), D31.N2
D19P4: CD29.BR2 (R2), D31.P2
D19R4: CD29.BM2 (M2), D31.R2
D19S4: CD29.BN2 (N2), D31.S2
GND: C25.C2 (GND), C26.C2 (GND), D30.C2 (GND), D31.C2 (GND); also elsewhere on the board
MA06: C26.E2; also elsewhere on the board
MA06_: C25.E2; also elsewhere on the board
MA07: C25.H2, C26.H2; also elsewhere on the board
MA08: C25.F2, C26.F2; also elsewhere on the board
MA09: D31.E2; also elsewhere on the board
MA09_: D30.E2; also elsewhere on the board
MA10: D30.H2, D31.H2; also elsewhere on the board
MA11: D30.F2, D31.F2; also elsewhere on the board
NEG_CLAMP: C25.V2, C26.V2, D30.V2, D31.V2; also elsewhere on the board
V24L4: C25.L2, CD27.AF2 (F2)
VCC: C25.A2 (VCC), C26.A2 (VCC), D30.A2 (VCC), D31.A2 (VCC); also elsewhere on the board
Y_RW_RETURN: D30.T2, D31.T2; also elsewhere on the board
Y_RW_SOURCE: C25.T2, C26.T2; also elsewhere on the board

Notes on the sheet:
D-BS-mc8i-0-4 Y Axis Selection
Core Memory:
* G611 in CD29 is replaced with G612 for MP8i.
C28
D28

Schematic: pdp8i-dec.sch, sheet 26

Parts:
A05: M113; H807
B04: M115; H807
B05: M216; H807
B06: M113; H807

Connections:
+3V(62): A05.U1, B06.J2 (IN2)
+3V(63): B05.R1 (S), B06.U2 (IN2), B06.V1
+3V(64): B04.F2 (IN3), B05.D1 (S), B06.U1
+3V(65): A05.D1 (IN1), B05.F2 (S), B05.N2 (S); also elsewhere on the board
+3V(66): A05.T2 (IN1); also elsewhere on the board
+3V(67): B04.V2 (IN3); also elsewhere on the board
B_EXT_INST: B04.C1 (IN3); also elsewhere on the board
CINT_: A05.L2 (IN1), B04.D1 (OUT)
CLEAR_IF_: B05.A1 (R); also elsewhere on the board
CUF: B06.K2 (OUT), B06.L1 (IN1)
CUF_: B06.C1 (OUT), B06.D1 (IN1), B06.H2 (IN1); also elsewhere on the board
EXT_GO: B06.D2 (IN1); also elsewhere on the board
GND: A05.C2 (GND), A05.T1 (GND), B04.C2 (GND), B04.T1 (GND), B05.C2 (GND), B05.T1 (GND), B05.T2 (D), B06.C2 (GND), B06.T1 (GND); also elsewhere on the board
IB_TO_IF: B05.D2 (C); also elsewhere on the board
IF_TO_SF: B05.N1 (C); also elsewhere on the board
INITIALIZE_: B05.K2 (R); also elsewhere on the board
I_IOT_: A05.J1 (IN2); also elsewhere on the board
KEY_LAMFTS0_: B06.R2 (IN2); also elsewhere on the board
MB06XMB09: B04.F1 (IN2), B06.B1 (IN2); also elsewhere on the board
MB07: B06.A1 (IN1); also elsewhere on the board
MB07_: B04.A1 (IN1), B04.H1 (IN3); also elsewhere on the board
MB08: B04.E1 (IN1), B06.M1 (IN2); also elsewhere on the board
MB08_: B04.B1 (IN2); also elsewhere on the board
MB09_: A05.B1 (IN2); also elsewhere on the board
MB10_: A05.A1 (IN1); also elsewhere on the board
MB11_: B04.D2 (IN1); also elsewhere on the board
ME05_: A05.K2 (OUT); also elsewhere on the board
unnamed: A05.E1 (IN2), B04.H2 (OUT)
unnamed: A05.D2 (IN1), A05.F1 (OUT)
unnamed: A05.C1 (OUT), A05.E2 (IN2)
unnamed: A05.F2 (OUT), A05.H1 (IN1)
unnamed: A05.U2 (IN2), B04.J1 (OUT)
unnamed: B06.E2 (IN2), B06.F1 (OUT)
unnamed: B06.L2 (IN1), B06.N1 (OUT)
unnamed: B06.M2 (IN2), B06.S1 (OUT)
unnamed: B05.C1 (D), B06.N2 (OUT)
unnamed: B06.F2 (OUT), B06.J1 (IN2)
unnamed: B05.B1 (C), B06.K1 (OUT)
unnamed: B06.S2 (OUT), B06.T2 (IN1)
unnamed: B05.E2 (D), B06.V2 (OUT)
unnamed: A05.K1 (OUT), A05.L1 (IN1)
unnamed: A05.N2 (OUT), A05.P1 (IN1)
unnamed: A05.N1 (OUT), A05.R1 (IN2), B04.P1 (IN1), B04.R1 (IN2)
unnamed: A05.S1 (OUT), B05.M2 (D)
unnamed: B04.S1 (IN3), B05.R2 (0)
unnamed: A05.P2 (IN1), A05.R2 (IN2), B04.U1 (OUT)
unnamed: B04.M2 (OUT), B05.U2 (S)
unnamed: B04.N1 (OUT), B05.S2 (C)
OP2: B04.E2 (IN2); also elsewhere on the board
PC_LOADXSR_ENABLE_: B06.H1 (IN1); also elsewhere on the board
PC_LOAD_: B04.M1 (IN3); also elsewhere on the board
RIB: A05.H2 (IN1); also elsewhere on the board
RMF_: B06.E1 (IN2); also elsewhere on the board
SF_ENABLE: B06.R1 (IN2); also elsewhere on the board
SINT: A05.V2 (OUT), B04.L2 (IN3)
SKIP_: B04.U2 (IN2); also elsewhere on the board
SKIP_OR: B04.V1 (OUT); also elsewhere on the board
S_UF: A05.J2 (IN2), B05.S1 (1), B06.P1 (IN1)
TP2E_: B04.K1 (IN1), B04.L1 (IN2); also elsewhere on the board
TP3: B04.K2 (IN2), B05.L2 (C); also elsewhere on the board
UB: B05.E1 (1), B06.P2 (IN1)
UF: A05.M1 (IN2), B05.H2 (1), B05.P1 (D)
UF_: B05.J2 (0); also elsewhere on the board
UINT: A05.M2 (IN2), B04.J2 (IN1), B05.P2 (1)
UINT_: A05.S2 (OUT); also elsewhere on the board
USF_: B04.T2 (IN1), B05.V1 (0)
VCC: A05.A2 (VCC), B04.A2 (VCC), B05.A2 (VCC), B06.A2 (VCC); also elsewhere on the board

Notes on the sheet:
NOTE:
8i-0-10
8i-0-12
8i-0-5
8i-0-6
PIN
PRINT
LOCATION
J13U2
C-6
A-6
B-4
D-2
D-3
(Locations refer to DEC drawings.)
F19N1
E27L1
F25S2
F25S1
D-BS-kt8i-0-1 Time-share Option

Schematic: pdp8i-dec.sch, sheet 27

Parts:
C13: M310; H807
C18: M113; H807
C22: M216; H807
D12, D13, D14, D15, D16: M113; H807
D17, D18, D19: M115; H807
D20, D21: M117; H807
D22: M617; H807
D23: M160; H807
D24: M216; H807
E22, E24: M113; H807

Connections:
+3V(24): C18.H2 (IN1), C18.U1; also elsewhere on the board
+3V(28): D12.E1 (IN2), D12.M1 (IN2), D12.U1, D13.J1 (IN2), D13.J2 (IN2); also elsewhere on the board
+3V(29): D14.P1 (IN1), D15.D2 (IN1), D15.H2 (IN1), D15.M2 (IN2), D15.P1 (IN1), D15.U1, D15.U2 (IN2)
+3V(30): D16.A1 (IN1), D16.D1 (IN1), D16.D2 (IN1), D16.M2 (IN2), D16.R1 (IN2), D16.R2 (IN2), D16.U1, D16.U2 (IN2)
+3V(31): D22.H1 (IN2), D22.J1 (IN3), D22.K1 (IN4), D22.L2 (IN2), D22.M1 (IN1), D22.M2 (IN3), D22.N1 (IN2), D22.N2 (IN4), D22.T2 (IN3), E22.V1
+3V(32): D23.M1 (IN5A), D24.D1 (S), D24.F2 (S), D24.K1 (S), D24.N2 (S), E24.U1; also elsewhere on the board
AC00: D15.E1 (IN2), D18.J2 (IN1); also elsewhere on the board
AC00_: D15.A1 (IN1); also elsewhere on the board
AC01: D14.L1 (IN1), D15.B1 (IN2); also elsewhere on the board
AC01_: D15.D1 (IN1), D16.H2 (IN1); also elsewhere on the board
AC02: D16.J2 (IN2); also elsewhere on the board
AC02_: D14.M1 (IN2), D20.D1 (IN4); also elsewhere on the board
AC03_: D19.K1 (IN1), D20.C1 (IN3); also elsewhere on the board
AC_TO_MQ_ENABLE: D15.S1 (OUT); also elsewhere on the board
AC_TO_MQ_ENABLE_: D15.R1 (IN2), D21.L1 (OUT); also elsewhere on the board
ADDER_L: D19.F1 (IN2); also elsewhere on the board
ASR_ENABLE: D15.V2 (OUT), D18.K2 (IN2); also elsewhere on the board
ASR_L_SET_: D18.M2 (OUT); also elsewhere on the board
B_EAE_ON: D13.B1 (IN2), D13.K1 (OUT), D17.C1 (IN3), D17.K1 (IN1), D17.L2 (IN3), D18.A1 (IN1), D18.P1 (IN1), D18.R2 (IN3), D20.E2 (IN2), D20.J1 (IN3); also elsewhere on the board
B_EXECUTE: D13.M2 (IN2), D14.E2 (IN2), D21.H2 (IN4); also elsewhere on the board
B_FETCH: D20.M1 (IN1); also elsewhere on the board
B_POWER_CLEAR_: D24.K2 (R); also elsewhere on the board
DIV_LAST: D12.A1 (IN1), D13.E2 (IN2), D16.K1 (OUT), D20.M2 (IN3), D23.E1 (IN2A)
DIV_LAST_: D12.C1 (OUT), D12.D2 (IN1), D12.L2 (IN1), D17.J2 (IN1), D20.H2 (IN4)
DVI: D12.B1 (IN2), D16.M1 (IN2), D16.S2 (OUT), D17.F1 (IN2), D17.M1 (IN3), D20.N2 (IN4), D23.F1 (IN2B)
DVI_: D16.P2 (IN1), D17.B1 (IN2), D19.V1 (OUT); also elsewhere on the board
EAE_ACBAR_ENABLE_: D13.A1 (IN1), D17.N1 (OUT), D17.P1 (IN1); also elsewhere on the board
EAE_AC_ENABLE_: D13.C1 (OUT); also elsewhere on the board
EAE_BEGIN: D12.R2 (IN2), D14.H1 (IN1), D14.K2 (OUT), D17.V2 (IN3)
EAE_COMPLETE_: C22.T2 (D), D15.J2 (IN2), D23.R1 (OUT)
EAE_END: C22.V2 (1); also elsewhere on the board
EAE_EXECUTE_: D13.N2 (OUT); also elsewhere on the board
EAE_E_SET_: D13.N1 (OUT); also elsewhere on the board
EAE_INST: D13.D1 (IN1), D13.K2 (OUT), D13.M1 (IN2), D14.R2 (IN2), D18.L1 (IN2), D20.U2 (IN4)
EAE_IR0: D18.B1 (IN2), D20.R2 (IN1), D24.E1 (1)
EAE_IR0_: D15.H1 (IN1), D19.N2 (IN1), D19.P1 (IN1), D19.T2 (IN1), D20.F1 (IN1), D24.F1 (0)
EAE_IR1: D15.J1 (IN2), D17.A1 (IN1), D18.C1 (IN3), D19.R1 (IN2), D19.U2 (IN2), D24.H2 (1)
EAE_IR1_: D19.P2 (IN2), D20.S2 (IN2), D24.J2 (0)
EAE_IR2: D19.R2 (IN3), D19.V2 (IN3), D24.L1 (1)
EAE_IR2_: D18.L2 (IN3), D19.S1 (IN3), D20.T2 (IN3), D24.M1 (0); also elsewhere on the board
EAE_IR_CLEAR_: D24.A1 (R); also elsewhere on the board
EAE_LEFT_SHIFT_ENABLE_: D20.J2 (OUT); also elsewhere on the board
EAE_L_DISABLE: D17.U1 (OUT); also elsewhere on the board
EAE_MEM_ENABLE_: D20.L1 (OUT); also elsewhere on the board
EAE_MQ0BAR_ENABLE_: D18.U1 (OUT); also elsewhere on the board
EAE_MQ0_ENABLE_: D18.S2 (OUT); also elsewhere on the board
EAE_NO_SHIFT_ENABLE: D17.M2 (OUT); also elsewhere on the board
EAE_ON: D24.P1 (D), D24.P2 (1); also elsewhere on the board
EAE_ON_: D13.H1 (IN1), D21.E2 (IN2), D24.R2 (0); also elsewhere on the board
EAE_RIGHT_SHIFT_ENABLE_: D17.D1 (OUT), D20.D2 (IN1); also elsewhere on the board
EAE_RUN: C22.U2 (S), D12.M2 (IN2), D14.A1 (IN1), D15.M1 (IN2), D24.S1 (1)
EAE_RUN_: D24.U1 (0)
EAE_SET_: D14.K1 (OUT); also elsewhere on the board
EAE_START_: D14.E1 (IN2), D17.V1 (OUT), D24.R1 (S); also elsewhere on the board
EAE_TG: D22.P1 (IN3), D22.R2 (IN1), D24.V2 (1)
EAE_TP: C13.J1 (OUT), C22.S2 (C), D14.B1 (IN2)
EAE_TP_: D12.P1 (IN1), D14.C1 (OUT), D14.D1 (IN1); also elsewhere on the board
GND: C13.C2 (GND), C13.T1 (GND), C18.C2 (GND), C18.T1 (GND), C22.C2 (GND), C22.T1 (GND), D12.C2 (GND), D12.T1 (GND), D13.C2 (GND), D13.T1 (GND), D14.C2 (GND), D14.T1 (GND), D15.C2 (GND), D15.T1 (GND), D16.C2 (GND), D16.T1 (GND), D17.C2 (GND), D17.T1 (GND), D18.C2 (GND), D18.T1 (GND), D19.C2 (GND), D19.T1 (GND), D20.C2 (GND), D20.T1 (GND), D21.C2 (GND), D21.T1 (GND), D22.C2 (GND), D22.T1 (GND), D23.C2 (GND), D23.H1 (IN3A), D23.J1 (IN3B), D23.T1 (GND), D24.C2 (GND), D24.T1 (GND), E22.C2 (GND), E22.T1 (GND), E24.C2 (GND), E24.T1 (GND); also elsewhere on the board
LOW_AC0: D21.D1 (IN4); also elsewhere on the board
MB03: D20.P1 (IN3); also elsewhere on the board
MB04_: D21.J1 (IN3); also elsewhere on the board
MB05: D18.D2 (IN1); also elsewhere on the board
MB06: D18.H1 (IN3); also elsewhere on the board
MB07: D18.K1 (IN1), D21.H1 (IN2); also elsewhere on the board
MB08: D24.C1 (D); also elsewhere on the board
MB09: D13.E1 (IN2), D24.E2 (D); also elsewhere on the board
MB09_: D13.P1 (IN1); also elsewhere on the board
MB10: D24.J1 (D); also elsewhere on the board
MB10_: D13.R1 (IN2); also elsewhere on the board
MB11: D18.E1 (IN1), D18.F2 (IN3), D20.R1 (IN4), D21.F1 (IN1); also elsewhere on the board
MB_TO_SC_ENABLE: D15.N2 (OUT); also elsewhere on the board
MFTS2_: D12.R1 (IN2); also elsewhere on the board
MID_AC0: D19.M1 (IN3), D20.B1 (IN2); also elsewhere on the board
MQ00: D18.S1 (IN3); also elsewhere on the board
MQ00_: D18.N2 (IN1), D21.K2 (IN1); also elsewhere on the board
MQ01_: D21.L2 (IN2); also elsewhere on the board
MQ02_: D21.M2 (IN3); also elsewhere on the board
MQ03_: D21.N2 (IN4); also elsewhere on the board
MQ04_: D21.M1 (IN1); also elsewhere on the board
MQ05_: D21.N1 (IN2); also elsewhere on the board
MQ06_: D21.P1 (IN3); also elsewhere on the board
MQ07_: D21.R1 (IN4); also elsewhere on the board
MQ08_: D21.R2 (IN1); also elsewhere on the board
MQ09_: D21.S2 (IN2); also elsewhere on the board
MQ10: D13.D2 (IN1), D23.V1 (IN2A); also elsewhere on the board
MQ10_: D12.E2 (IN2), D21.T2 (IN3); also elsewhere on the board
MQ11: D20.K2 (IN1), D23.U1 (IN1B); also elsewhere on the board
MQ11_: D13.U2 (IN2), D15.P2 (IN1), D21.U2 (IN4), D23.U2 (IN2B); also elsewhere on the board
MQ_ENABLE: D22.L1 (OUT); also elsewhere on the board
MQ_LOAD: D22.S1 (OUT); also elsewhere on the board
MQ_LOW_AC0: D15.F2 (OUT), D19.L1 (IN2), D20.A1 (IN1)
MUY: D15.R2 (IN2), D16.S1 (OUT), D23.A1 (IN1A)
MUY_: D16.P1 (IN1), D19.U1 (OUT)
MUY_DVI_: D15.K1 (OUT), D21.D2 (IN1)
unnamed: D16.H1 (IN1), D19.J1 (OUT)
unnamed: D16.J1 (IN2), D19.M2 (OUT)
unnamed: D19.E2 (IN2), D19.N1 (OUT)
unnamed: D16.K2 (OUT), D19.D2 (IN1)
unnamed: D14.N1 (OUT), D19.F2 (IN3)
unnamed: D19.H2 (OUT), D23.P1 (IN5C)
unnamed: D16.B1 (IN2), D21.P2 (OUT)
unnamed: D16.E1 (IN2), D21.S1 (OUT)
unnamed: D16.E2 (IN2), D21.V2 (OUT)
unnamed: D16.C1 (OUT), D21.A1 (IN1)
unnamed: D16.F2 (OUT), D21.C1 (IN3)
unnamed: D16.F1 (OUT), D21.B1 (IN2)
unnamed: D15.E2 (IN2), D21.E1 (OUT)
unnamed: D17.E2 (IN2), D20.E1 (OUT)
unnamed: D15.C1 (OUT), D17.D2 (IN1)
unnamed: D15.F1 (OUT), D17.F2 (IN3)
unnamed: D15.L2 (IN1), D21.J2 (OUT)
unnamed: D17.J1 (OUT), D17.K2 (IN2), D20.F2 (IN3)
unnamed: D17.L1 (IN2), D17.S2 (OUT)
unnamed: D15.S2 (OUT), D20.K1 (IN4)
unnamed: D17.P2 (IN2), D23.V2 (OUT)
unnamed: D20.H1 (IN2), D20.P2 (OUT)
unnamed: D12.D1 (IN1), D12.F2 (OUT)
unnamed: D13.F2 (OUT), D17.R2 (IN3)
unnamed: D12.F1 (OUT), D23.S1 (IN1A)
unnamed: D15.K2 (OUT), D15.L1 (IN1)
unnamed: D13.F1 (OUT), D17.R1 (IN2)
unnamed: D15.T2 (IN1), D17.S1 (IN3), D18.D1 (OUT)
unnamed: D18.H2 (OUT), D22.F1 (IN1)
unnamed: D18.N1 (OUT), D22.R1 (IN4)
unnamed: D12.S2 (OUT), D22.U2 (IN4)
unnamed: C13.E1 (IN), C13.S2
unnamed: C13.H1 (IN), C13.P2
unnamed: D18.J1 (OUT), D22.K2 (IN1)
unnamed: D14.V2 (OUT), D22.S2 (IN2)
unnamed: D14.S1 (OUT), D24.B1 (C), D24.D2 (C), D24.H1 (C)
unnamed: D14.R1 (IN2), D14.S2 (OUT)
unnamed: D14.F2 (OUT), D14.J2 (IN2)
unnamed: D12.N2 (OUT), D24.T2 (D)
unnamed: D12.N1 (OUT), D24.U2 (S)
unnamed: D12.S1 (OUT), D24.S2 (C)
unnamed: D14.H2 (IN1), D14.N2 (OUT)
unnamed: C13.H2, D14.F1 (OUT), D24.L2 (C)
unnamed: C13.F1 (OUT), D12.L1 (IN1), D24.N1 (C)
unnamed: D15.N1 (OUT), D24.M2 (D)
unnamed: D13.H2 (IN1), D20.S1 (OUT)
unnamed: D13.L1 (IN1), D13.S1 (OUT)
unnamed: D13.V2 (OUT), D16.L1 (IN1)
unnamed: D16.L2 (IN1), D16.N1 (OUT), D18.P2 (IN2)
unnamed: D16.N2 (OUT), D18.R1 (IN2)
NMI: D14.M2 (IN2), D14.U2 (IN2), D16.V2 (OUT), D23.N1 (IN5B)
NMI_: D16.T2 (IN1), D20.V2 (OUT)
NORM: C18.J2 (IN2), D17.H2 (OUT)
NORM_: C18.K2 (OUT), D14.L2 (IN1)
OP2: D18.E2 (IN2), D18.F1 (IN2), D21.K1 (IN4); also elsewhere on the board
OPR: D13.L2 (IN1), D14.D2 (IN1), D20.N1 (IN2), D21.F2 (IN3); also elsewhere on the board
SC0: D23.L1 (IN4B); also elsewhere on the board
SC0_3_0: D13.P2 (IN1), D19.E1 (IN1); also elsewhere on the board
SC0_3_0_: D17.N2 (IN1); also elsewhere on the board
SC1: D17.E1 (IN1), D19.J2 (IN1), D20.L2 (IN2), D23.B1 (IN1B); also elsewhere on the board
SC2: D17.H1 (IN3), D19.L2 (IN3); also elsewhere on the board
SC3: D23.C1 (IN1C); also elsewhere on the board
SC4: D19.K2 (IN2), D23.D1 (IN1D); also elsewhere on the board
SC4_: D13.R2 (IN2), D19.H1 (IN3); also elsewhere on the board
SCL_: D14.J1 (IN2), D17.T2 (IN1), D19.S2 (OUT)
SC_0_: D13.S2 (OUT), D13.T2 (IN1)
SC_ENABLE: D22.P2 (OUT); also elsewhere on the board
SC_FULL: D23.K1 (IN4A); also elsewhere on the board
SC_LOAD: D22.V2 (OUT); also elsewhere on the board
TP3: D12.P2 (IN1), D14.P2 (IN1), D14.T2 (IN1), D17.U2 (IN2), D18.M1 (IN3); also elsewhere on the board
VCC: C13.A2 (VCC), C18.A2 (VCC), C22.A2 (VCC), D12.A2 (VCC), D13.A2 (VCC), D14.A2 (VCC), D15.A2 (VCC), D16.A2 (VCC), D17.A2 (VCC), D18.A2 (VCC), D19.A2 (VCC), D20.A2 (VCC), D21.A2 (VCC), D22.A2 (VCC), D23.A2 (VCC), D24.A2 (VCC), E22.A2 (VCC), E24.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-ke8i-0-2 EAE Control
