# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8I/pdp8i-dec.brd (continued)

Schematic: pdp8i-dec.sch, sheet 28

Parts:
B21: M113; H807
C14, C15, C16, C17, C18: M113; H807
C19, C20, C21: M115; H807
C22, C23, C24: M216; H807
C40: M900; H807
D12: M113; H807
D19: M115; H807
D22: M617; H807
D23: M160; H807
E40: M900; H807
F40: M900; H807

Connections:
+3V(24): C18.A1 (IN1), C18.D1 (IN1), C18.D2 (IN1), C18.R2 (IN2), C18.U2 (IN2); also elsewhere on the board
+3V(25): B21.V1, C22.A1 (R), C22.D1 (S), C22.F2 (S), C22.K1 (S), C22.K2 (R), C22.N2 (S), C22.R1 (S)
+3V(26): C23.A1 (R), C23.D1 (S), C23.F2 (S), C23.K1 (S), C23.K2 (R), C23.N2 (S), C23.R1 (S), C23.U2 (S), D22.U1
+3V(27): C24.A1 (R), C24.D1 (S), C24.F2 (S), C24.K1 (S), C24.K2 (R), C24.N2 (S), C24.R1 (S), C24.U2 (S), D22.V1
+3V(28): D12.J2 (IN2), D12.T2 (IN1); also elsewhere on the board
+3V(32): D23.D2 (IN1A), D23.E2 (IN1B), D23.N2 (IN4A), D23.P2 (IN4B), D23.R2 (IN4C); also elsewhere on the board
AC00: C14.E1 (IN2); also elsewhere on the board
AC01: C14.J2 (IN2); also elsewhere on the board
AC02: C14.R1 (IN2); also elsewhere on the board
AC03: C15.E1 (IN2); also elsewhere on the board
AC04: C15.J2 (IN2); also elsewhere on the board
AC05: C15.R1 (IN2); also elsewhere on the board
AC06: C16.E1 (IN2); also elsewhere on the board
AC07: C16.J2 (IN2); also elsewhere on the board
AC08: C16.R1 (IN2); also elsewhere on the board
AC09: C17.E1 (IN2); also elsewhere on the board
AC10: C17.J2 (IN2); also elsewhere on the board
AC11: C17.R1 (IN2); also elsewhere on the board
AC_TO_MQ_ENABLE: C14.D1 (IN1), C14.H2 (IN1), C14.P1 (IN1), C15.D1 (IN1), C15.H2 (IN1), C15.P1 (IN1), C16.D1 (IN1), C16.H2 (IN1), C16.P1 (IN1), C17.D1 (IN1), C17.H2 (IN1), C17.P1 (IN1); also elsewhere on the board
ADDER11_: C14.B1 (IN2); also elsewhere on the board
ADDER_L: C18.V2 (OUT), D23.L2 (IN3A); also elsewhere on the board
ADDER_L_: C18.T2 (IN1), D23.K2 (IN2B); also elsewhere on the board
BB_LEFT_SHIFT: C16.D2 (IN1), C16.L1 (IN1), C16.P2 (IN1), C17.D2 (IN1), C17.L1 (IN1), C17.P2 (IN1), D12.V2 (OUT)
B_EAE_ON: D12.J1 (IN2); also elsewhere on the board
B_LEFT_SHIFT: C14.D2 (IN1), C14.L1 (IN1), C14.P2 (IN1), C15.D2 (IN1), C15.L1 (IN1), C15.P2 (IN1), D12.K2 (OUT)
DVI_: D23.S2 (IN4D); also elsewhere on the board
EAE_ON: C18.L2 (IN1), C21.A1 (IN1), C21.D2 (IN1), C21.E1 (IN1), C21.J2 (IN1), C21.K1 (IN1), C21.N2 (IN1), C21.R1 (IN2), C21.T2 (IN1); also elsewhere on the board
EAE_RIGHT_SHIFT_ENABLE_: D12.H1 (IN1); also elsewhere on the board
EAE_TP_: D22.D2 (IN1); also elsewhere on the board
GND: B21.C2 (GND), B21.T1 (GND), C14.C2 (GND), C14.T1 (GND), C15.C2 (GND), C15.T1 (GND), C16.C2 (GND), C16.T1 (GND), C17.C2 (GND), C17.T1 (GND), C18.C2 (GND), C18.T1 (GND), C19.C2 (GND), C19.T1 (GND), C20.C2 (GND), C20.T1 (GND), C21.C2 (GND), C21.T1 (GND), C22.C2 (GND), C22.T1 (GND), C23.C2 (GND), C23.T1 (GND), C24.C2 (GND), C24.T1 (GND), D12.C2 (GND), D12.T1 (GND), D19.C2 (GND), D19.T1 (GND), D22.C2 (GND), D22.T1 (GND), D23.C2 (GND), D23.T1 (GND); also elsewhere on the board
LEFT_SHIFT_: D12.H2 (IN1), D12.K1 (OUT), D12.U2 (IN2)
MB07_: C14.U2 (IN2); also elsewhere on the board
MB08_: C15.U2 (IN2); also elsewhere on the board
MB09_: C16.U2 (IN2); also elsewhere on the board
MB10_: C17.U2 (IN2); also elsewhere on the board
MB11_: C18.R1 (IN2); also elsewhere on the board
MB_TO_SC_ENABLE: C14.T2 (IN1), C15.T2 (IN1), C16.T2 (IN1), C17.T2 (IN1), C18.P1 (IN1); also elsewhere on the board
MQ00: C14.J1 (IN2), C23.E1 (1); also elsewhere on the board
MQ00_: C23.F1 (0), E40.S2; also elsewhere on the board
MQ01: C14.E2 (IN2), C14.M2 (IN2), C23.H2 (1); also elsewhere on the board
MQ01_: C23.J2 (0), E40.M2; also elsewhere on the board
MQ02: C14.M1 (IN2), C15.B1 (IN2), C23.L1 (1); also elsewhere on the board
MQ02_: C23.M1 (0), E40.N2; also elsewhere on the board
MQ03: C14.R2 (IN2), C15.J1 (IN2), C23.P2 (1); also elsewhere on the board
MQ03_: C23.R2 (0), E40.L2; also elsewhere on the board
MQ04: C15.E2 (IN2), C15.M2 (IN2), C23.S1 (1); also elsewhere on the board
MQ04_: C23.U1 (0), E40.F1; also elsewhere on the board
MQ05: C15.M1 (IN2), C16.B1 (IN2), C23.V2 (1); also elsewhere on the board
MQ05_: C23.V1 (0), E40.H1; also elsewhere on the board
MQ06: C15.R2 (IN2), C16.J1 (IN2), C24.E1 (1); also elsewhere on the board
MQ06_: C24.F1 (0), F40.S2; also elsewhere on the board
MQ07: C16.E2 (IN2), C16.M2 (IN2), C24.H2 (1); also elsewhere on the board
MQ07_: C24.J2 (0), F40.M2; also elsewhere on the board
MQ08: C16.M1 (IN2), C17.B1 (IN2), C24.L1 (1); also elsewhere on the board
MQ08_: C24.M1 (0), F40.N2; also elsewhere on the board
MQ09: C16.R2 (IN2), C17.J1 (IN2), C24.P2 (1); also elsewhere on the board
MQ09_: C24.R2 (0), F40.L2; also elsewhere on the board
MQ10: C17.E2 (IN2), C17.M2 (IN2), C24.S1 (1); also elsewhere on the board
MQ10_: C24.U1 (0), F40.F1; also elsewhere on the board
MQ11: C17.M1 (IN2), C24.V2 (1), D23.J2 (IN2A); also elsewhere on the board
MQ11_: C24.V1 (0), D23.M2 (IN3B), F40.H1; also elsewhere on the board
MQ_LOAD: C23.B1 (C), C23.D2 (C), C23.H1 (C), C23.L2 (C), C23.N1 (C), C23.S2 (C), C24.B1 (C), C24.D2 (C), C24.H1 (C), C24.L2 (C), C24.N1 (C), C24.S2 (C); also elsewhere on the board
unnamed: C14.F1 (OUT), C19.B1 (IN2)
unnamed: C14.K2 (OUT), C19.E2 (IN2)
unnamed: C14.S1 (OUT), C19.F1 (IN2)
unnamed: C15.F1 (OUT), C19.K2 (IN2)
unnamed: C15.K2 (OUT), C19.L1 (IN2)
unnamed: C15.S1 (OUT), C19.P2 (IN2)
unnamed: C16.F1 (OUT), C19.R1 (IN2)
unnamed: C16.K2 (OUT), C19.U2 (IN2)
unnamed: C16.S1 (OUT), C20.B1 (IN2)
unnamed: C17.F1 (OUT), C20.E2 (IN2)
unnamed: C17.K2 (OUT), C20.F1 (IN2)
unnamed: C17.S1 (OUT), C20.K2 (IN2)
unnamed: C14.C1 (OUT), C19.A1 (IN1)
unnamed: C14.F2 (OUT), C19.C1 (IN3)
unnamed: C14.K1 (OUT), C19.D2 (IN1)
unnamed: C14.N1 (OUT), C19.F2 (IN3)
unnamed: C14.N2 (OUT), C19.E1 (IN1)
unnamed: C14.S2 (OUT), C19.H1 (IN3)
unnamed: C15.C1 (OUT), C19.J2 (IN1)
unnamed: C15.F2 (OUT), C19.L2 (IN3)
unnamed: C15.K1 (OUT), C19.K1 (IN1)
unnamed: C15.N1 (OUT), C19.M1 (IN3)
unnamed: C15.N2 (OUT), C19.N2 (IN1)
unnamed: C15.S2 (OUT), C19.R2 (IN3)
unnamed: C16.C1 (OUT), C19.P1 (IN1)
unnamed: C16.F2 (OUT), C19.S1 (IN3)
unnamed: C16.K1 (OUT), C19.T2 (IN1)
unnamed: C16.N1 (OUT), C19.V2 (IN3)
unnamed: C16.N2 (OUT), C20.A1 (IN1)
unnamed: C16.S2 (OUT), C20.C1 (IN3)
unnamed: C17.C1 (OUT), C20.D2 (IN1)
unnamed: C17.F2 (OUT), C20.F2 (IN3)
unnamed: C17.K1 (OUT), C20.E1 (IN1)
unnamed: C17.N1 (OUT), C20.H1 (IN3)
unnamed: C17.N2 (OUT), C20.J2 (IN1)
unnamed: C17.S2 (OUT), C20.L2 (IN3)
unnamed: C19.D1 (OUT), C23.C1 (D)
unnamed: C19.H2 (OUT), C23.E2 (D)
unnamed: C19.J1 (OUT), C23.J1 (D)
unnamed: C19.M2 (OUT), C23.M2 (D)
unnamed: C19.N1 (OUT), C23.P1 (D)
unnamed: C19.S2 (OUT), C23.T2 (D)
unnamed: C19.U1 (OUT), C24.C1 (D)
unnamed: C19.V1 (OUT), C24.E2 (D)
unnamed: C20.D1 (OUT), C24.J1 (D)
unnamed: C20.H2 (OUT), C24.M2 (D)
unnamed: C20.J1 (OUT), C24.P1 (D)
unnamed: C20.M2 (OUT), C24.T2 (D)
unnamed: C20.L1 (IN2), C21.H2 (OUT)
unnamed: C20.K1 (IN1), C21.D1 (OUT)
unnamed: C14.V2 (OUT), C20.M1 (IN3)
unnamed: C20.N1 (OUT), C22.C1 (D)
unnamed: C18.L1 (IN1), C18.N2 (OUT)
unnamed: C18.M1 (IN2), C18.S1 (OUT)
unnamed: C20.S2 (OUT), C22.E2 (D)
unnamed: C20.U1 (OUT), C22.J1 (D)
unnamed: C20.V1 (OUT), C22.M2 (D)
unnamed: C18.N1 (OUT), C22.P1 (D)
unnamed: C20.N2 (IN1), C21.J1 (OUT)
unnamed: C20.P1 (IN1), C21.N1 (OUT)
unnamed: C20.T2 (IN1), C21.U1 (OUT)
unnamed: C20.P2 (IN2), C21.M2 (OUT)
unnamed: C20.R1 (IN2), C21.S2 (OUT)
unnamed: C20.U2 (IN2), C21.V1 (OUT)
unnamed: C15.V2 (OUT), C20.R2 (IN3)
unnamed: C16.V2 (OUT), C20.S1 (IN3)
unnamed: C17.V2 (OUT), C20.V2 (IN3)
unnamed: C18.B1 (IN2), C21.E2 (IN2), D22.E1 (OUT)
unnamed: C18.E1 (IN2), C21.K2 (IN2), D19.D1 (OUT)
unnamed: C18.F1 (OUT), C21.F1 (IN2)
unnamed: C18.E2 (IN2), C18.K1 (OUT), C21.P2 (IN2)
unnamed: C18.F2 (OUT), C21.L1 (IN2)
unnamed: C17.R2 (IN2), D23.T2 (OUT)
RIGHT_SHIFT: C14.A1 (IN1), C14.H1 (IN1), C14.L2 (IN1), C15.A1 (IN1), C15.H1 (IN1), C15.L2 (IN1), C16.A1 (IN1), C16.H1 (IN1), C16.L2 (IN1), C17.A1 (IN1), C17.H1 (IN1), C17.L2 (IN1); also elsewhere on the board
SC0: C21.F2 (IN3), C22.E1 (1); also elsewhere on the board
SC0_: C21.C1 (IN3), C22.F1 (0), C40.S2
SC0_3_0: C18.S2 (OUT), D23.F2 (IN1C); also elsewhere on the board
SC0_3_0_: C18.P2 (IN1), D22.J2 (OUT); also elsewhere on the board
SC1: C21.L2 (IN3), C22.H2 (1), D22.A1 (IN1); also elsewhere on the board
SC1_: C21.H1 (IN3), C22.J2 (0), C40.M2, D22.E2 (IN2)
SC2: C21.R2 (IN3), C22.L1 (1), D19.A1 (IN1), D22.B1 (IN2); also elsewhere on the board
SC2_: C21.M1 (IN3), C22.M1 (0), C40.N2, D22.F2 (IN3)
SC3: C18.H1 (IN1), C21.U2 (IN2), C22.P2 (1), D19.B1 (IN2), D22.C1 (IN3); also elsewhere on the board
SC3_: C21.P1 (IN1), C22.R2 (0), C40.L2, D22.H2 (IN4)
SC4: C18.J1 (IN2), C21.S1 (IN3), C22.S1 (1), D19.C1 (IN3), D22.D1 (IN4); also elsewhere on the board
SC4_: C18.M2 (IN2), C21.V2 (IN3), C22.U1 (0), C40.F1, D23.H2 (IN1D); also elsewhere on the board
SC_FULL: C18.C1 (OUT), C21.B1 (IN2); also elsewhere on the board
SC_LOAD: C22.B1 (C), C22.D2 (C), C22.H1 (C), C22.L2 (C), C22.N1 (C); also elsewhere on the board
VCC: B21.A2 (VCC), C14.A2 (VCC), C15.A2 (VCC), C16.A2 (VCC), C17.A2 (VCC), C18.A2 (VCC), C19.A2 (VCC), C20.A2 (VCC), C21.A2 (VCC), C22.A2 (VCC), C23.A2 (VCC), C24.A2 (VCC), D12.A2 (VCC), D19.A2 (VCC), D22.A2 (VCC), D23.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-ke8i-0-3 Multiplier Quot. and Step Counter

Schematic: pdp8i-dec.sch, sheet 29

Parts:
C07: M661; H807
C08: M660; H807
C09, C10: M113; H807
C11: M115; H807
D04: W011; H807
D05: M516; H807
D07: M113; H807
D09: M115; H807
D10: M117; H807
D11: M216; H807

Connections:
+3V(23): C10.B1 (IN2), C10.D1 (IN1), C10.D2 (IN1), C10.H2 (IN1), C10.J1 (IN2), C10.U2 (IN2), C11.B1 (IN2), D10.B1 (IN2), D10.C1 (IN3), D10.U1, D11.A1 (R)
+3V(57): C07.F2 (IN3), C07.H2 (IN2), C07.N2 (IN2), C07.P2 (IN3), C08.H2 (IN1), C08.N2 (IN1), C08.U2 (IN1), C09.E1 (IN2), C09.J1 (IN2), C09.M1 (IN2), C09.M2 (IN2), C09.R1 (IN2), C09.R2 (IN2), D10.V1, D11.K2 (R), D11.N2 (S)
+3V(58): D07.E2 (IN2), D09.H1 (IN3), D09.R1 (IN2), D09.V2 (IN3), D10.E2 (IN2); also elsewhere on the board
-15V: C07.B2 (-15V); also elsewhere on the board
BSTLR: C07.S2 (OUT), D04.M2
BTP3: C08.D2 (OUT), D04.E2
B_C_: C07.K2 (OUT), D04.K2
B_DC_INST: C08.S2 (OUT), D04.P2
B_FETCH: D10.N2 (IN4); also elsewhere on the board
B_LINE_HOLD_: C07.D2 (OUT), D04.D2
B_MEM_TO_LSR: C08.K2 (OUT), D04.H2
B_R0_: D04.V2, D05.D2 (IN), D05.E2 (IN2), D05.F2 (IN3), D05.H2 (IN4)
C: C10.P2 (IN1), C11.E1 (IN1), D09.E2 (IN2), D10.N1 (IN2), D10.S2 (IN2), D11.J2 (0)
CSR_ENABLE_: C11.E2 (IN2), D07.F1 (OUT)
C_: C07.M2 (IN1), D09.N2 (IN1), D11.H2 (1)
C_NO_SHIFT_: D07.C1 (OUT); also elsewhere on the board
C_SET_: C11.A1 (IN1), C11.R2 (IN3), D10.J2 (OUT), D11.E2 (D)
DC_INST_: C08.V2 (IN2), D09.J1 (OUT)
GND: C07.C2 (GND), C08.C2 (GND), C09.C2 (GND), C09.T1 (GND), C10.C2 (GND), C10.T1 (GND), C11.C2 (GND), C11.T1 (GND), D04.C2 (GND), D04.F2 (GND), D04.J2 (GND), D04.L2 (GND), D04.N2 (GND), D04.R2 (GND), D04.U2 (GND), D05.C2 (GND), D05.T1 (GND), D07.C2 (GND), D07.T1 (GND), D09.C2 (GND), D09.T1 (GND), D10.C2 (GND), D10.T1 (GND), D11.C2 (GND), D11.T1 (GND); also elsewhere on the board
HS: D07.B1 (IN2), D11.P2 (1)
HS_: C09.B1 (IN2), C11.F1 (IN2), D07.E1 (IN2), D11.R2 (0)
IOT: D09.F1 (IN2), D10.K2 (IN1); also elsewhere on the board
LHS: D05.E1 (OUT), D11.M2 (D)
LHS_: D04.T2, D05.A1 (IN), D05.B1 (IN2), D05.C1 (IN3), D05.D1 (IN4)
LH_TO_HS: D11.L2 (C); also elsewhere on the board
LINE_: C10.P1 (IN1), C10.T2 (IN1); also elsewhere on the board
LINE_HOLD_: C07.J2 (IN1), D09.M1 (IN3), D10.V2 (OUT)
MANUAL_PRESET_: D11.D1 (S), D11.F2 (S); also elsewhere on the board
MB03: C11.P1 (IN1); also elsewhere on the board
MB04_: C11.R1 (IN2); also elsewhere on the board
MB05_: C11.S1 (IN3); also elsewhere on the board
MB06_: C11.T2 (IN1); also elsewhere on the board
MB07_: C11.U2 (IN2); also elsewhere on the board
MB08_: C11.V2 (IN3); also elsewhere on the board
MB09: C11.L1 (IN2); also elsewhere on the board
MB10: D10.D1 (IN4), D10.F2 (IN3); also elsewhere on the board
MB11: D10.R1 (IN4), D10.U2 (IN4); also elsewhere on the board
MB11_: D09.F2 (IN3), D10.H2 (IN4); also elsewhere on the board
MEM00: C09.A1 (IN1); also elsewhere on the board
MEM09: D09.C1 (IN3); also elsewhere on the board
MEM_DONE_: C07.T2 (IN3); also elsewhere on the board
MEM_INH9_11_: C09.K2 (OUT), D10.J1 (IN3); also elsewhere on the board
MEM_TO_LSR_: C08.P2 (IN2); also elsewhere on the board
unnamed: D07.A1 (IN1), D07.D1 (IN1), D07.F2 (OUT)
unnamed: C09.L1 (IN1), D09.D1 (OUT)
unnamed: C09.J2 (IN2), C09.N1 (OUT)
unnamed: C09.C1 (OUT), C09.D1 (IN1), C11.K2 (IN2)
unnamed: C09.F1 (OUT), C09.H2 (IN1), D10.H1 (IN2)
unnamed: C11.D2 (IN1), C11.J1 (OUT)
unnamed: C10.A1 (IN1), C11.D1 (OUT)
unnamed: D09.T2 (IN1), D09.U1 (OUT)
unnamed: C10.K1 (OUT), D09.E1 (IN1), D10.L2 (IN2)
unnamed: C10.H1 (IN1), C11.U1 (OUT)
unnamed: C10.J2 (IN2), C11.V1 (OUT)
unnamed: C10.K2 (OUT), D10.M2 (IN3)
unnamed: C10.R2 (IN2), C10.V2 (OUT)
unnamed: C10.L2 (IN1), C10.S1 (OUT)
unnamed: C10.M2 (IN2), C10.S2 (OUT)
R0: C09.L2 (IN1), D05.J2 (OUT), D10.R2 (IN1)
R0_: C09.N2 (OUT), D10.M1 (IN1)
S: C07.U2 (IN2), C10.R1 (IN2), C11.L2 (IN3), C11.P2 (IN2), D09.A1 (IN1), D10.D2 (IN1), D10.K1 (IN4), D11.F1 (0); also elsewhere on the board
STORE_: D07.D2 (IN1), D09.P1 (IN1), D10.S1 (OUT); also elsewhere on the board
S_: D09.R2 (IN3), D11.E1 (1); also elsewhere on the board
S_SET_: C11.C1 (IN3), D10.E1 (OUT), D11.C1 (D)
TP3: C08.J2 (IN2), D09.U2 (IN2); also elsewhere on the board
TP4: D11.B1 (C), D11.D2 (C); also elsewhere on the board
TS1: C07.V2 (IN1); also elsewhere on the board
TS2: C11.H1 (IN3), C11.J2 (IN1), D09.B1 (IN2), D10.F1 (IN1); also elsewhere on the board
TS3: C11.K1 (IN1), C11.N2 (IN1), D09.D2 (IN1), D10.P1 (IN3), D10.T2 (IN3); also elsewhere on the board
TT_AC_LOAD_: D09.V1 (OUT); also elsewhere on the board
TT_CARRY_INSERT: C09.P1 (IN1), D09.N1 (OUT); also elsewhere on the board
TT_CARRY_INSERT_: C09.S1 (OUT); also elsewhere on the board
TT_CARRY_INSERT_C_: D09.H2 (OUT), D09.K1 (IN1)
TT_CARRY_INSERT_S: C09.S2 (OUT); also elsewhere on the board
TT_CARRY_INSERT_S_: C09.P2 (IN1), C11.S2 (OUT), D09.L1 (IN2)
TT_CYCLE_: C10.N1 (OUT); also elsewhere on the board
TT_DATA: C10.N2 (OUT); also elsewhere on the board
TT_INCREMENT_: D10.L1 (OUT); also elsewhere on the board
TT_INST: C10.F2 (OUT), C11.M1 (IN3), D10.A1 (IN1)
TT_INST_: C10.E2 (IN2), C10.M1 (IN2), D09.P2 (IN2), D10.P2 (OUT); also elsewhere on the board
TT_IO_ENABLE_: C11.F2 (IN3), C11.N1 (OUT), D09.S1 (IN3); also elsewhere on the board
TT_LINE_SHIFT_: C09.D2 (IN1), C11.M2 (OUT); also elsewhere on the board
TT_L_DISABLE: C10.L1 (IN1), D09.S2 (OUT); also elsewhere on the board
TT_RIGHT_SHIFT_ENABLE: C10.E1 (IN2), C11.H2 (OUT)
TT_RIGHT_SHIFT_ENABLE_: C09.E2 (IN2), C10.F1 (OUT); also elsewhere on the board
TT_SET_: C10.C1 (OUT); also elsewhere on the board
TT_SHIFT_ENABLE: C09.F2 (OUT), C09.H1 (IN1); also elsewhere on the board
TT_SHIFT_ENABLE_: C09.K1 (OUT); also elsewhere on the board
VCC: C07.A2 (VCC), C08.A2 (VCC), C09.A2 (VCC), C10.A2 (VCC), C11.A2 (VCC), D05.A2 (VCC), D07.A2 (VCC), D09.A2 (VCC), D10.A2 (VCC), D11.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-dl8i-0-2 Data Line Interface

Schematic: pdp8i-dec.sch, sheet 30

Parts:
A09, A10: M162; H807
B07: M115; H807
B09: M113; H807
H05: W011; H807

Connections:
+3V(05): A10.D1 (8B); also elsewhere on the board
+3V(06): B09.H2 (IN1), B09.U1; also elsewhere on the board
+3V(07): B07.F1 (IN2), B07.K1 (IN1), B07.P2 (IN2), B07.R2 (IN3), B09.J1 (IN2), B09.M2 (IN2), B09.V1
CLR_PARITY_ERROR_: B07.S2 (OUT), B09.P1 (IN1)
GND: A09.C2 (GND), A09.T1 (GND), A10.C2 (GND), A10.J1 (8A), A10.T1 (GND), B07.C2 (GND), B07.T1 (GND), B09.C2 (GND), B09.T1 (GND), H05.C2 (GND), H05.F2 (GND), H05.J2 (GND), H05.L2 (GND), H05.N2 (GND), H05.R2 (GND), H05.U2 (GND); also elsewhere on the board
INITIALIZE_: B07.L1 (IN2); also elsewhere on the board
IOP1: B07.K2 (IN2); also elsewhere on the board
IOP4: B07.E1 (IN1); also elsewhere on the board
MB00: A09.E1 (1A); also elsewhere on the board
MB00_: A09.A1 (1B); also elsewhere on the board
MB01: A09.F1 (2A); also elsewhere on the board
MB01_: A09.B1 (2B); also elsewhere on the board
MB02: A09.H1 (4A); also elsewhere on the board
MB02_: A09.C1 (4B); also elsewhere on the board
MB03: A09.J1 (8A); also elsewhere on the board
MB03_: A09.D1 (8B), B07.A1 (IN1); also elsewhere on the board
MB04: A10.P2 (1A); also elsewhere on the board
MB04_: A10.K2 (1B), B07.B1 (IN2); also elsewhere on the board
MB05: A10.R2 (2A), B07.C1 (IN3); also elsewhere on the board
MB05_: A10.L2 (2B); also elsewhere on the board
MB06: A10.S2 (4A); also elsewhere on the board
MB06_: A10.M2 (4B), B07.D2 (IN1); also elsewhere on the board
MB07: A10.T2 (8A); also elsewhere on the board
MB07_: A10.N2 (8B), B07.E2 (IN2); also elsewhere on the board
MB08: A09.P2 (1A); also elsewhere on the board
MB08_: A09.K2 (1B), B07.F2 (IN3); also elsewhere on the board
MB09: A09.R2 (2A); also elsewhere on the board
MB09_: A09.L2 (2B); also elsewhere on the board
MB10: A09.S2 (4A); also elsewhere on the board
MB10_: A09.M2 (4B); also elsewhere on the board
MB11: A09.T2 (8A); also elsewhere on the board
MB11_: A09.N2 (8B); also elsewhere on the board
MB_PARITY_ODD: A10.K1 (ODD), H05.T2; also elsewhere on the board
MEM_PARITY_EVEN_: B09.U2 (IN2); also elsewhere on the board
MP_INT: B09.R1 (IN2), B09.S2 (OUT)
MP_INT_: B07.L2 (IN3), B09.P2 (IN1), B09.S1 (OUT); also elsewhere on the board
MP_SKIP_: B07.M2 (OUT); also elsewhere on the board
unnamed: A09.L1 (EVEN), A10.A1 (1B)
unnamed: A09.K1 (ODD), A10.E1 (1A)
unnamed: A10.B1 (2B), A10.V2 (EVEN)
unnamed: A10.F1 (2A), A10.U2 (ODD)
unnamed: A09.V2 (EVEN), A10.C1 (4B)
unnamed: A09.U2 (ODD), A10.H1 (4A)
unnamed: B07.D1 (OUT), B09.H1 (IN1)
unnamed: B07.H2 (OUT), B09.J2 (IN2)
unnamed: B09.K1 (OUT), B09.L1 (IN1)
unnamed: B09.K2 (OUT), B09.M1 (IN2)
unnamed: B07.H1 (IN3), B07.J2 (IN1), B09.N2 (OUT)
unnamed: B09.L2 (IN1), B09.N1 (OUT)
unnamed: B07.J1 (OUT), B07.M1 (IN3)
unnamed: B07.N1 (OUT), B07.N2 (IN1)
unnamed: B09.R2 (IN2), B09.V2 (OUT)
TP3: B09.T2 (IN1); also elsewhere on the board
VCC: A09.A2 (VCC), A10.A2 (VCC), B07.A2 (VCC), B09.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mp8i-0-1 Memory Parity Option (1/2)

Schematic: pdp8i-dec.sch, sheet 31

Parts:
A07, A08: M162; H807
B08, B09: M113; H807

Connections:
+3V(05): B08.B1 (IN2), B08.E1 (IN2), B08.E2 (IN2), B08.J1 (IN2), B08.J2 (IN2), B08.M1 (IN2), B08.M2 (IN2), B08.U1; also elsewhere on the board
+3V(06): B08.R1 (IN2), B08.R2 (IN2), B08.U2 (IN2), B09.B1 (IN2), B09.D2 (IN1), B09.E1 (IN2); also elsewhere on the board
GND: A07.C2 (GND), A07.T1 (GND), A08.C2 (GND), A08.T1 (GND), B08.C2 (GND), B08.T1 (GND), B09.C2 (GND), B09.T1 (GND); also elsewhere on the board
MEM00: A07.E1 (1A), B08.H1 (IN1); also elsewhere on the board
MEM01: A07.F1 (2A), B08.D2 (IN1); also elsewhere on the board
MEM02: A07.H1 (4A), B08.D1 (IN1); also elsewhere on the board
MEM03: A07.J1 (8A), B08.A1 (IN1); also elsewhere on the board
MEM04: A08.P2 (1A), B08.P1 (IN1); also elsewhere on the board
MEM05: A08.R2 (2A), B08.L2 (IN1); also elsewhere on the board
MEM06: A08.S2 (4A), B08.L1 (IN1); also elsewhere on the board
MEM07: A08.T2 (8A), B08.H2 (IN1); also elsewhere on the board
MEM08: A07.P2 (1A), B09.D1 (IN1); also elsewhere on the board
MEM09: A07.R2 (2A), B09.A1 (IN1); also elsewhere on the board
MEM10: A07.S2 (4A), B08.T2 (IN1); also elsewhere on the board
MEM11: A07.T2 (8A), B08.P2 (IN1); also elsewhere on the board
MEM_P: A08.J1 (8A), B08.V1, B09.E2 (IN2); also elsewhere on the board
MEM_PARITY_EVEN_: A08.L1 (EVEN); also elsewhere on the board
unnamed: A07.L1 (EVEN), A08.A1 (1B)
unnamed: A07.K1 (ODD), A08.E1 (1A)
unnamed: A08.B1 (2B), A08.V2 (EVEN)
unnamed: A08.F1 (2A), A08.U2 (ODD)
unnamed: A07.V2 (EVEN), A08.C1 (4B)
unnamed: A07.U2 (ODD), A08.H1 (4A)
unnamed: A08.M2 (4B), B08.N1 (OUT)
unnamed: A08.L2 (2B), B08.N2 (OUT)
unnamed: A08.K2 (1B), B08.S1 (OUT)
unnamed: A08.N2 (8B), B08.K2 (OUT)
unnamed: A07.M2 (4B), B08.V2 (OUT)
unnamed: A07.B1 (2B), B08.F2 (OUT)
unnamed: A07.C1 (4B), B08.F1 (OUT)
unnamed: A07.D1 (8B), B08.C1 (OUT)
unnamed: A07.A1 (1B), B08.K1 (OUT)
unnamed: A07.L2 (2B), B09.C1 (OUT)
unnamed: A07.K2 (1B), B09.F1 (OUT)
unnamed: A07.N2 (8B), B08.S2 (OUT)
unnamed: A08.D1 (8B), B09.F2 (OUT)
VCC: A07.A2 (VCC), A08.A2 (VCC), B08.A2 (VCC), B09.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-mp8i-0-1 Memory Parity Option (2/2)

Schematic: pdp8i-dec.sch, sheet 32

Parts:
A04: M703; H807

Connections:
GND: A04.C2 (GND), A04.T1 (GND); also elsewhere on the board
INITIALIZE_: A04.S2; also elsewhere on the board
IOP2: A04.M2; also elsewhere on the board
MB03_: A04.D2; also elsewhere on the board
MB04_: A04.E2; also elsewhere on the board
MB05: A04.F2; also elsewhere on the board
MB06_: A04.H2; also elsewhere on the board
MB07_: A04.J2; also elsewhere on the board
MB08_: A04.K2; also elsewhere on the board
PWR_LOW_: A04.R2; also elsewhere on the board
PWR_SKIP_: A04.L2; also elsewhere on the board
RESTART: A04.N2; also elsewhere on the board
RESTART_: A04.U1; also elsewhere on the board
SHUT_DOWN_: A04.U2; also elsewhere on the board
STOP_OK: A04.P2; also elsewhere on the board
VCC: A04.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-kp8i-0-1 Power Fail and Restart Option

Schematic: pdp8i-dec.sch, sheet 33

Parts:
D03: W023; H807
HJ23: M701; H807-2
HJ24, HJ25: A607; H807-2

Connections:
-15V: D03.B2, HJ24.AB2 (-15V), HJ24.BB2 (-15V), HJ25.AB2 (-15V), HJ25.BB2 (-15V); also elsewhere on the board
-30V: HJ23.AV2 (-30V); also elsewhere on the board
AC02: HJ24.AE2, HJ25.AE2; also elsewhere on the board
AC03: HJ24.AF2, HJ25.AF2; also elsewhere on the board
AC04: HJ24.AM2, HJ25.AM2; also elsewhere on the board
AC05: HJ24.AN2, HJ25.AN2; also elsewhere on the board
AC06: HJ24.AS2, HJ25.AS2; also elsewhere on the board
AC07: HJ24.AT2, HJ25.AT2; also elsewhere on the board
AC08: HJ24.BD2, HJ25.BD2; also elsewhere on the board
AC09: HJ24.BE2, HJ25.BE2; also elsewhere on the board
AC10: HJ24.BH2, HJ25.BH2; also elsewhere on the board
AC11: HJ24.BJ2, HJ25.BJ2; also elsewhere on the board
CLEAR_X_: HJ23.AS2, HJ24.AL2
CLEAR_Y_: HJ23.AR2, HJ25.AL2
GND: D03.C2, HJ23.AC2 (GND), HJ23.AT1 (GND), HJ23.BC2 (GND), HJ23.BT1 (GND), HJ24.AC2 (GND), HJ24.BC2 (GND), HJ25.AC2 (GND), HJ25.BC2 (GND); also elsewhere on the board
INITIALIZE: HJ23.AH2; also elsewhere on the board
IOP1: HJ23.AR1; also elsewhere on the board
IOP2: HJ23.AJ2; also elsewhere on the board
IOP4: HJ23.BD2; also elsewhere on the board
IO_BUS_IN_INT_: HJ23.BP2; also elsewhere on the board
IO_BUS_IN_SKIP_: HJ23.BR2; also elsewhere on the board
LIGHT_PEN: D03.V2, HJ23.AN2
MB03_: HJ23.BF2; also elsewhere on the board
MB04_: HJ23.BH2; also elsewhere on the board
MB05_: HJ23.BK2; also elsewhere on the board
MB06: HJ23.BM2; also elsewhere on the board
MB07: HJ23.BL2; also elsewhere on the board
MB07_: HJ23.BE2; also elsewhere on the board
MB08: HJ23.BN2; also elsewhere on the board
MB08_: HJ23.BJ2; also elsewhere on the board
MB09_: HJ23.AK2; also elsewhere on the board
MB10: HJ23.AN1; also elsewhere on the board
MB11: HJ23.AP1; also elsewhere on the board
PEN_STROBE: HJ23.AJ1, HJ23.AK1
VCC: D03.A2, HJ23.AA2 (VCC), HJ23.BA2 (VCC), HJ24.AA2 (VCC), HJ24.BA2 (VCC), HJ25.AA2 (VCC), HJ25.BA2 (VCC); also elsewhere on the board
X_AXIS: D03.D2, HJ24.BS2
X_STROBE: HJ23.AS1, HJ24.AD2
Y_AXIS: D03.E2, HJ25.BS2
Y_STROBE: HJ23.AP2, HJ25.AD2
Z_AXIS: D03.F2, HJ23.AE2

Notes on the sheet:
D-BS-vc8i-0-1 Display Control

Schematic: pdp8i-dec.sch, sheet 34

Parts:
D02: W023; H807
HJ29: M704; H807-2

Connections:
DRUM_DOWN: D02.T2, HJ29.AR2
DRUM_UP: D02.S2, HJ29.AN2
GND: D02.C2, HJ29.AC2 (GND), HJ29.AT1 (GND), HJ29.BC2 (GND), HJ29.BT1 (GND); also elsewhere on the board
INITIALIZE: HJ29.BN2; also elsewhere on the board
IOP1: HJ29.BH2; also elsewhere on the board
IOP1_: HJ29.BL2; also elsewhere on the board
IOP2: HJ29.BP2; also elsewhere on the board
IOP2_: HJ29.BM2; also elsewhere on the board
IOP4: HJ29.BT2; also elsewhere on the board
IO_BUS_IN_INT_: HJ29.BF2; also elsewhere on the board
IO_BUS_IN_SKIP_: HJ29.BE2; also elsewhere on the board
MB03: HJ29.AF2; also elsewhere on the board
MB04_: HJ29.AH2; also elsewhere on the board
MB05: HJ29.AE2; also elsewhere on the board
MB06_: HJ29.AD2; also elsewhere on the board
MB07: HJ29.AS2; also elsewhere on the board
MB07_: HJ29.BU1; also elsewhere on the board
MB08: HJ29.AK2; also elsewhere on the board
MB08_: HJ29.BV1; also elsewhere on the board
PEN_DOWN: D02.V2, HJ29.AV2
PEN_LEFT: D02.R2, HJ29.AL2
PEN_RIGHT: D02.P2, HJ29.AJ2
PEN_UP: D02.U2, HJ29.AT2
VCC: HJ29.AA2 (VCC), HJ29.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-vp8i-0-1 Plotter Control

Schematic: pdp8i-dec.sch, sheet 35

Parts:
C01: W023; H807
C02, C03, C04, C05, C06: M040; H807
HJ28: M710; H807-2

Connections:
+3VC01: C01.V2, HJ28.BU2
-15V: C02.B2 (-15V), C03.B2 (-15V), C04.B2 (-15V), C05.B2 (-15V), C06.B2 (-15V); also elsewhere on the board
-36V: C01.D2, C02.V2, C03.V2, C04.V2, C05.V2, C06.V2
AC04: HJ28.AH1; also elsewhere on the board
AC05: HJ28.AH2; also elsewhere on the board
AC06: HJ28.AF1; also elsewhere on the board
AC07: HJ28.AF2; also elsewhere on the board
AC08: HJ28.AE1; also elsewhere on the board
AC09: HJ28.AE2; also elsewhere on the board
AC10: HJ28.AD1; also elsewhere on the board
AC11: HJ28.AD2; also elsewhere on the board
FEED_HOLE: C01.H2, C01.T2, C04.S2 (R)
GND: C01.C2, C01.E2, C02.C2 (GND), C03.C2 (GND), C04.C2 (GND), C05.C2 (GND), C06.C2 (GND), HJ28.AC2 (GND), HJ28.AT1 (GND), HJ28.BC2 (GND), HJ28.BT1 (GND); also elsewhere on the board
HOLE1: C01.J2, C06.R2 (R)
HOLE2: C01.S2, C05.S2 (R)
HOLE3: C01.R2, C05.R2 (R)
HOLE4: C01.P2, C04.R2 (R)
HOLE5: C01.N2, C03.S2 (R)
HOLE6: C01.M2, C03.R2 (R)
HOLE7: C01.L2, C02.S2 (R)
HOLE8: C01.K2, C02.R2 (R)
INITIALIZE_: HJ28.AS2; also elsewhere on the board
IOP1: HJ28.AR2; also elsewhere on the board
IOP2: HJ28.AR1; also elsewhere on the board
IOP4: HJ28.AP2; also elsewhere on the board
IO_BUS_IN_INT_: HJ28.BS2; also elsewhere on the board
IO_BUS_IN_SKIP_: HJ28.BN2; also elsewhere on the board
MB03_: HJ28.BF2; also elsewhere on the board
MB04_: HJ28.BD1; also elsewhere on the board
MB05_: HJ28.BD2; also elsewhere on the board
MB06_: HJ28.BE1; also elsewhere on the board
MB07: HJ28.BE2; also elsewhere on the board
MB08_: HJ28.BF1; also elsewhere on the board
unnamed: HJ28.AU1, HJ28.BV1
unnamed: C02.D2 (D), C02.J2 (D), C03.D2 (D), C03.J2 (D), C04.D2 (D), C04.J2 (D), C04.K2 (E), C04.L2 (F), C04.M2 (H), C05.D2 (D), C05.J2 (D), C06.D2 (D), HJ28.BH2
unnamed: C02.E2 (E), C02.F2 (F), C02.H2 (H), HJ28.AK1
unnamed: C02.K2 (E), C02.L2 (F), C02.M2 (H), HJ28.AL1
unnamed: C06.E2 (E), C06.F2 (F), C06.H2 (H), HJ28.AN2
unnamed: C03.E2 (E), C03.F2 (F), C03.H2 (H), HJ28.AM1
unnamed: C03.K2 (E), C03.L2 (F), C03.M2 (H), HJ28.AN1
unnamed: C04.E2 (E), C04.F2 (F), C04.H2 (H), HJ28.AK2
unnamed: C05.E2 (E), C05.F2 (F), C05.H2 (H), HJ28.AL2
unnamed: C05.K2 (E), C05.L2 (F), C05.M2 (H), HJ28.AM2
PUN_FEED_SWITCH_: C01.U2, HJ28.AT2
SYNC_PUN: C01.F2, HJ28.AV2
VCC: C02.A2 (VCC), C03.A2 (VCC), C04.A2 (VCC), C05.A2 (VCC), C06.A2 (VCC), HJ28.AA2 (VCC), HJ28.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
IOT 1
IOT 2
IOT 4
D-BS-pp8i-0-1 High Speed Punch

Schematic: pdp8i-dec.sch, sheet 36

Parts:
D01: W077; H807
HJ26: M705; H807-2
HJ27: M715; H807-2

Connections:
-15V: D01.B2, HJ27.BB2 (-15V); also elsewhere on the board
BA: D01.R2, HJ26.BP2
BA_: D01.P2, HJ26.BS1
BB: D01.T2, HJ26.BU2
BB_: D01.S2, HJ26.BR1
CLOCK1: HJ26.BS2, HJ27.AU2 (AU)
GND: HJ26.AC2 (GND), HJ26.AT1 (GND), HJ26.BC2 (GND), HJ26.BT1 (GND), HJ27.AC2 (GND), HJ27.BC2 (GND); also elsewhere on the board
INITIALIZE_: HJ26.BP1; also elsewhere on the board
IOP1: HJ26.AU2; also elsewhere on the board
IOP2: HJ26.AV2; also elsewhere on the board
IOP4: HJ26.BK1; also elsewhere on the board
IO_BUS_IN04_: HJ26.AP2; also elsewhere on the board
IO_BUS_IN05_: HJ26.AS2; also elsewhere on the board
IO_BUS_IN06_: HJ26.AR1; also elsewhere on the board
IO_BUS_IN07_: HJ26.AN2; also elsewhere on the board
IO_BUS_IN08_: HJ26.AS1; also elsewhere on the board
IO_BUS_IN09_: HJ26.AP1; also elsewhere on the board
IO_BUS_IN10_: HJ26.AR2; also elsewhere on the board
IO_BUS_IN11_: HJ26.AN1; also elsewhere on the board
IO_BUS_IN_INT_: HJ26.AL2; also elsewhere on the board
IO_BUS_IN_SKIP_: HJ26.AK2; also elsewhere on the board
MB03_: HJ26.BD2; also elsewhere on the board
MB04_: HJ26.BE2; also elsewhere on the board
MB05_: HJ26.BE1; also elsewhere on the board
MB06_: HJ26.BF2; also elsewhere on the board
MB07_: HJ26.BF1; also elsewhere on the board
MB08: HJ26.BH2; also elsewhere on the board
PWR: D01.U2, HJ26.BR2
RDR_ENABLE_: HJ26.BK2, HJ27.AK2 (AK)
RDR_FEED_SWITCH: D01.V2, HJ26.BM1, HJ27.BP2 (BP)
RDR_RUN_: HJ26.AK1, HJ27.BS2 (BS)
RDR_SHIFT: HJ26.BJ1, HJ27.AS2 (AS)
RDR_SHIFT_: HJ26.BD1, HJ27.AT2 (AT)
RD_HOLE1: D01.D2, HJ26.AD2
RD_HOLE2: D01.E2, HJ26.AD1
RD_HOLE3: D01.F2, HJ26.AE2
RD_HOLE4: D01.H2, HJ26.AE1
RD_HOLE5: D01.J2, HJ26.AH2
RD_HOLE6: D01.K2, HJ26.AH1
RD_HOLE7: D01.L2, HJ26.AF2
RD_HOLE8: D01.M2, HJ26.AF1
STOP_COMPLETE: HJ26.BN2, HJ27.BR2 (BR)
S_FEED_HOLE: D01.N2, HJ26.BM2
VCC: HJ26.AA2 (VCC), HJ26.BA2 (VCC), HJ27.AA2 (VCC), HJ27.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-pr8i-0-1 High Speed Reader

Schematic: pdp8i-dec.sch, sheet 37

Parts:
H30: M708; H807
HJ31: M709; H807-2
J30: M401/M405/M501; H807

Connections:
60HZ_IN: J30.R2
+3V(46): J30.K2; also elsewhere on the board
AC00: HJ31.AE1; also elsewhere on the board
AC01: HJ31.BA1; also elsewhere on the board
AC02: HJ31.AV1; also elsewhere on the board
AC03: HJ31.AH1; also elsewhere on the board
AC04: HJ31.AU2; also elsewhere on the board
AC05: HJ31.AK1; also elsewhere on the board
AC06: HJ31.AT2; also elsewhere on the board
AC07: HJ31.AL1; also elsewhere on the board
AC08: HJ31.AR1; also elsewhere on the board
AC09: HJ31.AN2; also elsewhere on the board
AC10: HJ31.AR2; also elsewhere on the board
AC11: HJ31.AP1; also elsewhere on the board
CLOCK: H30.D2, HJ31.BJ2, J30.D2, J30.F2
CLOCK_AC_CLR_: HJ31.BM2; also elsewhere on the board
CLOCK_ENABLE_: H30.J2, J30.J2
CLOCK_IOT: H30.S1, HJ31.BL1
CLOCK_P4: H30.K2, HJ31.BK1
GND: H30.C2 (GND), H30.T1 (GND), HJ31.AC2 (GND), HJ31.AT1 (GND), HJ31.BC2 (GND), HJ31.BT1 (GND), J30.C2 (GND); also elsewhere on the board
INITIALIZE_: H30.P1; also elsewhere on the board
IOP1_: H30.L2; also elsewhere on the board
IOP2_: H30.R1; also elsewhere on the board
IOP4_: H30.F2; also elsewhere on the board
IO_BUS_IN00_: HJ31.AF2; also elsewhere on the board
IO_BUS_IN01_: HJ31.BD1; also elsewhere on the board
IO_BUS_IN02_: HJ31.AF1; also elsewhere on the board
IO_BUS_IN03_: HJ31.BB1; also elsewhere on the board
IO_BUS_IN04_: HJ31.AJ2; also elsewhere on the board
IO_BUS_IN05_: HJ31.AU1; also elsewhere on the board
IO_BUS_IN06_: HJ31.AJ1; also elsewhere on the board
IO_BUS_IN07_: HJ31.AV2; also elsewhere on the board
IO_BUS_IN08_: HJ31.AM1; also elsewhere on the board
IO_BUS_IN09_: HJ31.AP2; also elsewhere on the board
IO_BUS_IN10_: HJ31.AM2; also elsewhere on the board
IO_BUS_IN11_: HJ31.AS1; also elsewhere on the board
IO_BUS_IN_INT_: H30.C1; also elsewhere on the board
IO_BUS_IN_SKIP_: H30.H1; also elsewhere on the board
LOAD_COUNTER: H30.V2, HJ31.BN1
MB03_: H30.T2; also elsewhere on the board
MB04_: H30.S2; also elsewhere on the board
MB05: H30.R2; also elsewhere on the board
MB06_: H30.P2; also elsewhere on the board
MB07: H30.N2; also elsewhere on the board
MB08: H30.M2; also elsewhere on the board
MB09: H30.U2; also elsewhere on the board
MB09_: H30.N1; also elsewhere on the board
MB10: H30.L1, HJ31.BJ1; also elsewhere on the board
MB10_: HJ31.BP1; also elsewhere on the board
MB11: H30.A1; also elsewhere on the board
OVERFLOW: H30.V1, HJ31.BS1
VCC: H30.A2 (VCC), HJ31.AA2 (VCC), HJ31.BA2 (VCC), J30.A2 (VCC); also elsewhere on the board

Notes on the sheet:
J30
D-BS-kw8i-0-1 Real Time Clock Option
Clock Control

Schematic: pdp8i-dec.sch, sheet 38

Parts:
HJ34: W991; H807-2
J33: M714; H807

Connections:
BIOP1: J33.F2; also elsewhere on the board
BIOP2: J33.H2; also elsewhere on the board
BIOP4: J33.F1; also elsewhere on the board
CR_READ: HJ34.BP2, J33.S2
CR_READY: HJ34.AK2, J33.R2
C_I_R: HJ34.BR2, J33.U2
GND: J33.C2 (GND), J33.T1 (GND); also elsewhere on the board
INDEX_MARKERS: HJ34.BH2, J33.J1; also elsewhere on the board
INITIALIZE_: J33.N1; also elsewhere on the board
IOT632: J33.P1; also elsewhere on the board
IOT634: J33.R1; also elsewhere on the board
IO_BUS_IN_INT_: J33.N2; also elsewhere on the board
IO_BUS_IN_SKIP_: J33.P2; also elsewhere on the board
I_M_D: J33.K1; also elsewhere on the board
MB03: J33.C1; also elsewhere on the board
MB04: J33.D2; also elsewhere on the board
MB05_: J33.B1; also elsewhere on the board
MB06: J33.D1; also elsewhere on the board
MB06_: J33.E2; also elsewhere on the board
MB07: J33.A1; also elsewhere on the board
MB08: J33.E1; also elsewhere on the board
VCC: J33.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-cr8i-0-2 Card Reader Control #1

Schematic: pdp8i-dec.sch, sheet 39

Parts:
HJ32: M716; H807-2
HJ34: W991; H807-2

Connections:
GND: HJ32.AC2 (GND), HJ32.AT1 (GND), HJ32.BC2 (GND), HJ32.BT1 (GND), HJ34.AC2, HJ34.BC2; also elsewhere on the board
INDEX_MARKERS: HJ32.AD2; also elsewhere on the board
INITIALIZE_: HJ32.BS2; also elsewhere on the board
IOT632: HJ32.BM2; also elsewhere on the board
IOT634: HJ32.AH1; also elsewhere on the board
IO_BUS_IN00_: HJ32.AF1; also elsewhere on the board
IO_BUS_IN01_: HJ32.AF2; also elsewhere on the board
IO_BUS_IN02_: HJ32.AH2; also elsewhere on the board
IO_BUS_IN03_: HJ32.AJ2; also elsewhere on the board
IO_BUS_IN04_: HJ32.AN2; also elsewhere on the board
IO_BUS_IN05_: HJ32.AM2; also elsewhere on the board
IO_BUS_IN06_: HJ32.AU2; also elsewhere on the board
IO_BUS_IN07_: HJ32.AV2; also elsewhere on the board
IO_BUS_IN08_: HJ32.BP2; also elsewhere on the board
IO_BUS_IN09_: HJ32.BN2; also elsewhere on the board
IO_BUS_IN10_: HJ32.BJ2; also elsewhere on the board
IO_BUS_IN11_: HJ32.BH2; also elsewhere on the board
I_M_D: HJ32.BU1; also elsewhere on the board
VCC: HJ32.AA2 (VCC), HJ32.BA2 (VCC); also elsewhere on the board
ZONE01_INDEX: HJ32.AK2, HJ34.BD2
ZONE02_INDEX: HJ32.AR2, HJ34.BE2
ZONE03_INDEX: HJ32.AP2, HJ34.BF2
ZONE04_INDEX: HJ32.BE2, HJ34.BJ2
ZONE05_INDEX: HJ32.AS2, HJ34.BK2
ZONE06_INDEX: HJ32.BS1, HJ34.BL2
ZONE07_INDEX: HJ32.BR1, HJ34.BM2
ZONE08_INDEX: HJ32.BK2, HJ34.BN2
ZONE09_INDEX: HJ32.BL2, HJ34.BS2
ZONE10_INDEX: HJ32.AL2, HJ34.BT2
ZONE11_INDEX: HJ32.AE1, HJ34.BU2
ZONE12_INDEX: HJ32.AE2, HJ34.BV2

Notes on the sheet:
D-BS-cr8i-0-3 Card Reader Control #2
HJ32
M716
Card Reader Control
