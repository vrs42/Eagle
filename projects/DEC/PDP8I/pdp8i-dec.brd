# Repository vrs42/Eagle (continued)

## EAGLE design projects/DEC/PDP8L/pdp8l.brd (continued)

Schematic: pdp8l.sch, sheet 12

Parts:
A32, A33: M516; H807
A34: M111; H807
B12: M111; H807
B32, B33: M906; H807
C27: M623; H807
C29, C30: M660; H807
C35, C36: M903; H807
D11: M113; H807
D13: M111; H807
D27, D28: M623; H807
D29, D30: M906; H807
D34, D35, D36: M903; H807

Connections:
3CYCLE: A34.V2 (OUT); also elsewhere on the board
!3CYCLE: A34.U2 (IN), B33.K2, C35.K2
!ADD_ACCEPTED: C27.R2 (A); also elsewhere on the board
!BAC_CLEAR: A33.M1 (IN), D34.P2
!BADDR00: B32.B1, C36.B1, D11.P1 (IN1), D11.R1 (IN2)
!BADDR01: B32.D1, C36.D1, D11.P2 (IN1), D11.R2 (IN2)
!BADDR02: B32.E1, C36.E1, D11.T2 (IN1), D11.U2 (IN2)
!BADDR03: B12.J1 (IN), B32.H1, C36.H1
!BADDR04: B32.J1, C36.J1, D13.A1 (IN)
!BADDR05: B32.L1, C36.L1, D13.J1 (IN)
!BADDR06: B32.M1, C36.M1, D13.P2 (IN)
!BADDR07: B32.P1, C36.P1, D13.S2 (IN)
!BADDR08: B32.S1, C36.S1, D13.U2 (IN)
!BADDR09: A34.A1 (IN), B32.D2, C36.D2
!BADDR10: A34.C1 (IN), B32.E2, C36.E2
!BADDR11: A34.D1 (IN), B32.H2, C36.H2
!BADD_ACCEPTED: B32.S2, C27.U2 (D), C36.S2
!BBREAK: B32.P2, C27.P2 (E), C36.P2
!BDATA00: A34.F1 (IN), B33.B1, C35.B1
!BDATA01: A34.J1 (IN), B33.D1, C35.D1
!BDATA02: A34.L1 (IN), B33.E1, C35.E1
!BDATA03: A34.N1 (IN), B33.H1, C35.H1
!BDATA04: A34.R1 (IN), B33.J1, C35.J1
!BDATA05: A34.V1 (IN), B33.L1, C35.L1
!BDATA06: A34.E2 (IN), B33.M1, C35.M1
!BDATA07: A34.H2 (IN), B33.P1, C35.P1
!BDATA08: A34.K2 (IN), B33.S1, C35.S1
!BDATA09: A34.M2 (IN), B33.D2, C35.D2
!BDATA10: A34.P2 (IN), B33.E2, C35.E2
!BDATA11: A34.S2 (IN), B33.H2, C35.H2
!BIRQ: A33.K2 (IN), D34.M2
!BMB03: D28.L1 (E), D30.H1, D35.H1
!BMB04: D28.S1 (E), D30.L1, D35.L1
!BMB05: D28.J2 (E), D30.P1, D35.P1
!BMB06: D28.P2 (E), D30.D2, D35.D2
!BMB07: D28.V2 (E), D30.H2, D35.H2
!BMB08: C27.E1 (E), D30.M2, D35.M2
!BMEM_INCR: A33.R2 (IN), C36.T2
!BREAK: C27.L2 (B); also elsewhere on the board
!BRK_RQST: C36.K2, D29.T2; also elsewhere on the board
!BSKIP: A33.F1 (IN), D34.K2
!EXT_ADD2: B33.S2, C35.S2
!IB00: D13.E2 (IN), D29.K2, D34.B1
!IB01: D13.H2 (IN), D29.M2, D34.D1
!IB02: D13.K2 (IN), D29.P2, D34.E1
!IB03: D13.M2 (IN), D29.S2, D34.H1
!IB04: A32.A1 (IN), D34.J1
!IB05: A32.D2 (IN), D34.L1
!IB06: A32.F1 (IN), D34.M1
!IB07: A32.K2 (IN), D34.P1
!IB08: A32.M1 (IN), D34.S1
!IB09: A32.R2 (IN), D34.D2
!IB10: A33.A1 (IN), D34.E2
!IB11: A33.D2 (IN), D34.H2
!INITIALIZE: C30.U2 (IN1), C30.V2 (IN2); also elsewhere on the board
!INT_IO_BUS4: A32.B1 (IN2), A32.D1 (IN4); also elsewhere on the board
!INT_IO_BUS5: A32.E2 (IN2), A32.H2 (IN4); also elsewhere on the board
!INT_IO_BUS6: A32.H1 (IN2), A32.K1 (IN4); also elsewhere on the board
!INT_IO_BUS7: A32.L2 (IN2), A32.N2 (IN4); also elsewhere on the board
!INT_IO_BUS8: A32.N1 (IN2), A32.R1 (IN4); also elsewhere on the board
!INT_IO_BUS9: A32.S2 (IN2), A32.U2 (IN4); also elsewhere on the board
!INT_IO_BUS10: A33.B1 (IN2), A33.D1 (IN4); also elsewhere on the board
!INT_IO_BUS11: A33.E2 (IN2), A33.H2 (IN4); also elsewhere on the board
!IOP1: C29.H2 (IN1), C29.J2 (IN2); also elsewhere on the board
!IOP2: C29.N2 (IN1), C29.P2 (IN2); also elsewhere on the board
!IOP4: C29.U2 (IN1), C29.V2 (IN2); also elsewhere on the board
!MB03: D28.H1 (B); also elsewhere on the board
!MB04: D28.N1 (B); also elsewhere on the board
!MB05: D28.E2 (B); also elsewhere on the board
!MB06: D28.L2 (B); also elsewhere on the board
!MB07: D28.S2 (B); also elsewhere on the board
!MB08: C27.B1 (B); also elsewhere on the board
!PWR_LOW: A33.N2 (IN4); also elsewhere on the board
!PWR_SKP: A33.K1 (IN4); also elsewhere on the board
!RDR_INT: A33.L2 (IN2); also elsewhere on the board
!RDR_SKP: A33.H1 (IN2); also elsewhere on the board
!RUN: C27.D2 (A); also elsewhere on the board
!TS1: C30.N2 (IN1), C30.P2 (IN2); also elsewhere on the board
!TS3: C30.H2 (IN1), C30.J2 (IN2); also elsewhere on the board
!TT0: A32.C1 (IN3); also elsewhere on the board
!TT1: A32.F2 (IN3); also elsewhere on the board
!TT2: A32.J1 (IN3); also elsewhere on the board
!TT3: A32.M2 (IN3); also elsewhere on the board
!TT4: A32.P1 (IN3); also elsewhere on the board
!TT5: A32.T2 (IN3); also elsewhere on the board
!TT6: A33.C1 (IN3); also elsewhere on the board
!TT7: A33.F2 (IN3); also elsewhere on the board
!TT_AC_CLEAR: A33.N1 (IN2), A33.P1 (IN3), A33.R1 (IN4); also elsewhere on the board
!TT_INT: A33.M2 (IN3); also elsewhere on the board
!TT_SKIP: A33.J1 (IN3); also elsewhere on the board
!WC_OVERFLOW: C27.K2 (A); also elsewhere on the board
A33S2: A33.S2 (IN2), A33.T2 (IN3), A33.U2 (IN4)
AC00: D27.A1 (A); also elsewhere on the board
AC01: D27.B1 (B); also elsewhere on the board
AC02: D27.F1 (A); also elsewhere on the board
AC03: D27.H1 (B); also elsewhere on the board
AC04: D27.M1 (A); also elsewhere on the board
AC05: D27.N1 (B); also elsewhere on the board
AC06: D27.D2 (A); also elsewhere on the board
AC07: D27.E2 (B); also elsewhere on the board
AC08: D27.K2 (A); also elsewhere on the board
AC09: D27.L2 (B); also elsewhere on the board
AC10: D27.R2 (A); also elsewhere on the board
AC11: D27.S2 (B); also elsewhere on the board
AC_CLEAR: A33.S1 (OUT); also elsewhere on the board
BAC00: D27.D1 (D), D29.B1, D36.B1
BAC01: D27.E1 (E), D29.D1, D36.D1
BAC02: D27.K1 (D), D29.E1, D36.E1
BAC03: D27.L1 (E), D29.H1, D36.H1
BAC04: D27.R1 (D), D29.J1, D36.J1
BAC05: D27.S1 (E), D29.L1, D36.L1
BAC06: D27.H2 (D), D29.M1, D36.M1
BAC07: D27.J2 (E), D29.P1, D36.P1
BAC08: D27.N2 (D), D29.S1, D36.S1
BAC09: D27.P2 (E), D29.D2, D36.D2
BAC10: D27.U2 (D), D29.E2, D36.E2
BAC11: D27.V2 (E), D29.H2, D36.H2
BINITIALIZE: C30.S2 (OUT), D36.V2
BINITIALIZE2: B32.V2, C27.V2 (E), C36.V2
BIOP1: C29.D2 (OUT), D36.K2
BIOP2: C29.K2 (OUT), D36.M2
BIOP4: C29.S2 (OUT), D36.P2
BMB00: D28.D1 (D), D30.B1, D35.B1
BMB01: D28.E1 (E), D30.D1, D35.D1
BMB02: D28.K1 (D), D30.E1, D35.E1
BMB03: D28.R1 (D), D30.J1, D35.J1
BMB04: D28.H2 (D), D30.M1, D35.M1
BMB05: D28.N2 (D), D30.S1, D35.S1
BMB06: D28.U2 (D), D30.E2, D35.E2
BMB07: C27.D1 (D), D30.K2, D35.K2
BMB08: C27.K1 (D), D30.P2, D35.P2
BMB09: C27.L1 (E), D30.S2, D35.S2
BMB10: C27.R1 (D), D30.T2, D35.T2
BMB11: C27.S1 (E), D30.V2, D35.V2
BRUN: C27.H2 (D), D29.V2, D34.S2
BTS1: C30.K2 (OUT), D36.T2
BTS3: C30.D2 (OUT), D36.S2
CA_INCREMENT: B33.M2, C35.M2; also elsewhere on the board
DATA00: A34.H1 (OUT); also elsewhere on the board
DATA01: A34.K1 (OUT); also elsewhere on the board
DATA02: A34.M1 (OUT); also elsewhere on the board
DATA03: A34.P1 (OUT); also elsewhere on the board
DATA04: A34.S1 (OUT); also elsewhere on the board
DATA05: A34.U1 (OUT); also elsewhere on the board
DATA06: A34.F2 (OUT); also elsewhere on the board
DATA07: A34.J2 (OUT); also elsewhere on the board
DATA08: A34.L2 (OUT); also elsewhere on the board
DATA09: A34.N2 (OUT); also elsewhere on the board
DATA10: A34.R2 (OUT); also elsewhere on the board
DATA11: A34.T2 (OUT); also elsewhere on the board
DATA_ADD00: D11.S1 (OUT); also elsewhere on the board
DATA_ADD01: D11.S2 (OUT); also elsewhere on the board
DATA_ADD02: D11.V2 (OUT); also elsewhere on the board
DATA_ADD03: B12.K1 (OUT); also elsewhere on the board
DATA_ADD04: D13.B1 (OUT); also elsewhere on the board
DATA_ADD05: D13.K1 (OUT); also elsewhere on the board
DATA_ADD06: D13.R2 (OUT); also elsewhere on the board
DATA_ADD07: D13.T2 (OUT); also elsewhere on the board
DATA_ADD08: D13.V2 (OUT); also elsewhere on the board
DATA_ADD09: A34.B1 (OUT); also elsewhere on the board
DATA_ADD10: A34.D2 (OUT); also elsewhere on the board
DATA_ADD11: A34.E1 (OUT); also elsewhere on the board
DATA_IN: B32.M2, C36.M2; also elsewhere on the board
GND: A32.C2 (GND), A32.T1 (GND), A33.C2 (GND), A33.T1 (GND), A34.C2 (GND), A34.T1 (GND), B12.C2 (GND), B12.T1 (GND), B32.A1 (GND), B32.C1 (GND), B32.C2 (GND), B32.F1 (GND), B32.F2 (GND), B32.J2 (GND), B32.K1 (GND), B32.L2 (GND), B32.N1 (GND), B32.N2 (GND), B32.R1 (GND), B32.R2 (GND), B32.T1 (GND), B32.U2 (GND), B33.A1 (GND), B33.C1 (GND), B33.C2 (GND), B33.F1 (GND), B33.F2 (GND), B33.J2 (GND), B33.K1 (GND), B33.L2 (GND), B33.N1 (GND), B33.N2 (GND), B33.R1 (GND), B33.R2 (GND), B33.T1 (GND), B33.U2 (GND), C27.C1 (C), C27.C2 (GND), C27.E2 (B), C27.F2 (C), C27.J1 (C), C27.M2 (C), C27.P1 (C), C27.T1 (GND), C27.T2 (C), C27.U1 (GND), C27.V1 (GND), C29.C2 (GND), C30.C2 (GND), C35.A1 (GND), C35.C1 (GND), C35.C2 (GND), C35.F1 (GND), C35.F2 (GND), C35.J2 (GND), C35.K1 (GND), C35.L2 (GND), C35.N1 (GND), C35.N2 (GND), C35.R1 (GND), C35.R2 (GND), C35.T1 (GND), C35.U2 (GND), C36.A1 (GND), C36.C1 (GND), C36.C2 (GND), C36.F1 (GND), C36.F2 (GND), C36.J2 (GND), C36.K1 (GND), C36.L2 (GND), C36.N1 (GND), C36.N2 (GND), C36.R1 (GND), C36.R2 (GND), C36.T1 (GND), C36.U2 (GND), D11.C2 (GND), D11.T1 (GND), D13.C2 (GND), D13.T1 (GND), D27.C1 (C), D27.C2 (GND), D27.F2 (C), D27.J1 (C), D27.M2 (C), D27.P1 (C), D27.T1 (GND), D27.T2 (C), D27.U1 (GND), D27.V1 (GND), D28.C1 (C), D28.C2 (GND), D28.F2 (C), D28.J1 (C), D28.M2 (C), D28.P1 (C), D28.T1 (GND), D28.T2 (C), D28.U1 (GND), D28.V1 (GND), D29.A1 (GND), D29.C1 (GND), D29.C2 (GND), D29.F1 (GND), D29.F2 (GND), D29.J2 (GND), D29.K1 (GND), D29.L2 (GND), D29.N1 (GND), D29.N2 (GND), D29.R1 (GND), D29.R2 (GND), D29.T1 (GND), D29.U2 (GND), D30.A1 (GND), D30.C1 (GND), D30.C2 (GND), D30.F1 (GND), D30.F2 (GND), D30.J2 (GND), D30.K1 (GND), D30.L2 (GND), D30.N1 (GND), D30.N2 (GND), D30.R1 (GND), D30.R2 (GND), D30.T1 (GND), D30.U2 (GND), D34.A1 (GND), D34.C1 (GND), D34.C2 (GND), D34.F1 (GND), D34.F2 (GND), D34.J2 (GND), D34.K1 (GND), D34.L2 (GND), D34.N1 (GND), D34.N2 (GND), D34.R1 (GND), D34.R2 (GND), D34.T1 (GND), D34.U2 (GND), D35.A1 (GND), D35.C1 (GND), D35.C2 (GND), D35.F1 (GND), D35.F2 (GND), D35.J2 (GND), D35.K1 (GND), D35.L2 (GND), D35.N1 (GND), D35.N2 (GND), D35.R1 (GND), D35.R2 (GND), D35.T1 (GND), D35.U2 (GND), D36.A1 (GND), D36.C1 (GND), D36.C2 (GND), D36.F1 (GND), D36.F2 (GND), D36.J2 (GND), D36.K1 (GND), D36.L2 (GND), D36.N1 (GND), D36.N2 (GND), D36.R1 (GND), D36.R2 (GND), D36.T1 (GND), D36.U2 (GND); also elsewhere on the board
INITIALIZE: C27.S2 (B); also elsewhere on the board
INPUT_BUS00: D13.F2 (OUT); also elsewhere on the board
INPUT_BUS01: D13.J2 (OUT); also elsewhere on the board
INPUT_BUS02: D13.L2 (OUT); also elsewhere on the board
INPUT_BUS03: D13.N2 (OUT); also elsewhere on the board
INPUT_BUS04: A32.E1 (OUT); also elsewhere on the board
INPUT_BUS05: A32.J2 (OUT); also elsewhere on the board
INPUT_BUS06: A32.L1 (OUT); also elsewhere on the board
INPUT_BUS07: A32.P2 (OUT); also elsewhere on the board
INPUT_BUS08: A32.S1 (OUT); also elsewhere on the board
INPUT_BUS09: A32.V2 (OUT); also elsewhere on the board
INPUT_BUS10: A33.E1 (OUT); also elsewhere on the board
INPUT_BUS11: A33.J2 (OUT); also elsewhere on the board
INT_RQST: A33.P2 (OUT); also elsewhere on the board
IO_SKIP: A33.L1 (OUT); also elsewhere on the board
MB00: D28.A1 (A); also elsewhere on the board
MB01: D28.B1 (B); also elsewhere on the board
MB02: D28.F1 (A); also elsewhere on the board
MB03: D28.M1 (A); also elsewhere on the board
MB04: D28.D2 (A); also elsewhere on the board
MB05: D28.K2 (A); also elsewhere on the board
MB06: D28.R2 (A); also elsewhere on the board
MB07: C27.A1 (A); also elsewhere on the board
MB08: C27.F1 (A); also elsewhere on the board
MB09: C27.H1 (B); also elsewhere on the board
MB10: C27.M1 (A); also elsewhere on the board
MB11: C27.N1 (B); also elsewhere on the board
MEMORY_INCREMENT: A33.V2 (OUT); also elsewhere on the board
VCC: A32.A2 (VCC), A33.A2 (VCC), A34.A2 (VCC), B12.A2 (VCC), B32.A2 (VCC), B33.A2 (VCC), C27.A2 (VCC), C29.A2 (VCC), C30.A2 (VCC), D11.A2 (VCC), D13.A2 (VCC), D27.A2 (VCC), D28.A2 (VCC), D29.A2 (VCC), D30.A2 (VCC); also elsewhere on the board
WC_OVERFLOW: B33.P2, C27.N2 (D), C35.P2

Notes on the sheet:
I/O Converters
D-BS-8L-0-10

Schematic: pdp8l.sch, sheet 13

Parts:
C32: M706A; H807
D32: M706B; H807
D33: W076; H807

Connections:
!IN_STOP2: D32.R2, D32.V2
!KCC: C32.E2, C32.V2
!MB03: C32.D2; also elsewhere on the board
!MB04: C32.E1; also elsewhere on the board
!MB05: C32.F1; also elsewhere on the board
!MB06: C32.H1; also elsewhere on the board
!TT0: C32.K2; also elsewhere on the board
!TT1: C32.R2; also elsewhere on the board
!TT2: C32.S2; also elsewhere on the board
!TT3: C32.L1; also elsewhere on the board
!TT4: C32.M1; also elsewhere on the board
!TT5: C32.P2; also elsewhere on the board
!TT6: C32.T2; also elsewhere on the board
!TT7: C32.N2; also elsewhere on the board
!TTI_FLAG: C32.F2; also elsewhere on the board
!TTI_SKIP: D32.H2; also elsewhere on the board
!TT_AC_CLEAR: D32.E2; also elsewhere on the board
+3V(16): C32.D1, D32.R1
-15V: D33.B2; also elsewhere on the board
CLOCK_SCALE2: D32.P2, D32.T2
GND: C32.C2, C32.T1, D32.C2, D32.D1, D32.T1, D33.C2; also elsewhere on the board
INITIALIZE: D32.F2; also elsewhere on the board
IOP1: D32.D2; also elsewhere on the board
IOP2: D32.J2; also elsewhere on the board
IOP4: C32.L2; also elsewhere on the board
MB07: C32.H2; also elsewhere on the board
MB08: C32.J1; also elsewhere on the board
MEM_SUPPLY-: D33.V2; also elsewhere on the board
READER_RUN: C32.U2, D33.M2
RXD: D32.M2, D33.E2
SPIKE_DETECT: C32.M2, C32.R1
TTI_CLOCK: C32.N1; also elsewhere on the board
TTY8BITS: C32.J2, C32.K1
TXD: D33.H2; also elsewhere on the board
VCC: C32.A2, D32.A2, D33.A2; also elsewhere on the board

Notes on the sheet:
CD32
M706
Enable
8 Bits
2 Stop Bits
Set RR
D-BS-8L-0-11
Teletype Receiver

Schematic: pdp8l.sch, sheet 14

Parts:
A14: M115; H807
C26: M002; H807
C31: M707A; H807
C33: M452; H807
D13: M111; H807
D31: M707B; H807

Connections:
!MB03: C31.E2; also elsewhere on the board
!MB04: C31.E1; also elsewhere on the board
!MB05: C31.F2; also elsewhere on the board
!MB07: C31.H2; also elsewhere on the board
!MB08: C31.J2; also elsewhere on the board
!MP_INT: A14.F2 (IN3), C26.V2; also elsewhere on the board
!MP_SKIP: A14.R2 (IN3), C26.R2; also elsewhere on the board
!OUT_STOP2: D31.N1, D31.N2
!TTI_FLAG: A14.D2 (IN1); also elsewhere on the board
!TTI_SKIP: A14.N2 (IN1); also elsewhere on the board
!TTO_CLOCK: C33.K2, D31.P2
!TTO_ENABLE: C31.H1, C31.L1
!TTO_FLAG: A14.E2 (IN2), D31.K2
!TTO_SKIP: A14.P2 (IN2), D31.J2
!TT_INT: D13.M1 (OUT); also elsewhere on the board
!TT_SKIP: D13.U1 (OUT); also elsewhere on the board
+3V(15): C31.N1, C31.N2, D31.F2, D31.J1, D31.S2
AC04: C31.P2; also elsewhere on the board
AC05: C31.R2; also elsewhere on the board
AC06: C31.L2; also elsewhere on the board
AC07: C31.M2; also elsewhere on the board
AC08: C31.U2; also elsewhere on the board
AC09: C31.S2; also elsewhere on the board
AC10: C31.T2; also elsewhere on the board
AC11: C31.U1; also elsewhere on the board
GND: A14.C2 (GND), A14.T1 (GND), C26.C2 (GND), C31.C2, C31.T1, C33.C2, D13.C2 (GND), D13.T1 (GND), D31.C2, D31.T1; also elsewhere on the board
HZ880: C33.J2, C33.P2
INITIALIZE: D31.E2; also elsewhere on the board
IOP1: D31.H2; also elsewhere on the board
IOP2: D31.D2; also elsewhere on the board
IOP4: C31.S1; also elsewhere on the board
MB06: C31.F1; also elsewhere on the board
TTI_CLOCK: C33.R2; also elsewhere on the board
TTO_ENABLE: C31.K1, C31.K2
TT_INT: A14.H2 (OUT), D13.L1 (IN)
TT_SKIP: A14.S2 (OUT), D13.V1 (IN)
TXD: C31.V2; also elsewhere on the board
VCC: A14.A2 (VCC), C26.A2 (VCC), C31.A2, C33.A2, D13.A2 (VCC), D31.A2; also elsewhere on the board

Notes on the sheet:
CD31
M707
8 Bits
M452
C33
D-BS-8L-0-12
Teletype Transmitter

Schematic: pdp8l.sch, sheet 15

Parts:
A01: G921; H807
A25, A26: G624; H807
A27: G826A; H807
A28: G785A; H807
B01: G921; H807
B22: W025B; H807
B25, B26: G624; H807
B27: G826B; H807
B28: G785B; H807
B34, B36: M903; H807
C01: G921; H807
C13: M117; H807
C15: M113; H807
C17: M360; H807
C25: G228; H807
C26: M002; H807
D01: G921; H807
D13: M111; H807
D14, D15: M310; H807
D16: M216; H807
D17: M617; H807
D25: G228; H807

Connections:
!B_MEM_ENABLE: D16.F1 (0), D17.A1 (IN1), D17.B1 (IN2), D17.C1 (IN3), D17.D1 (IN4), D17.F1 (IN1), D17.H1 (IN2), D17.J1 (IN3), D17.K1 (IN4)
!EA: B34.B1, C13.R2 (IN1), C26.D2, D16.C1 (D)
!INHIBIT: D16.R2 (0), D17.D2 (IN1), D17.E2 (IN2), D17.F2 (IN3), D17.H2 (IN4), D17.P1 (IN3), D17.R1 (IN4)
!LOCK: C13.S2 (IN2), C13.T2 (IN3), C15.L1 (IN1), D16.V1 (0)
!MEM_BEGIN: D16.K1 (S), D16.U2 (S), D17.S1 (OUT); also elsewhere on the board
!MEM_DONE: C17.V2 (OUT); also elsewhere on the board
!POWER_CLEAR: A27.S2, D16.A1 (R), D16.K2 (R); also elsewhere on the board
!POWER_OK: A27.J2; also elsewhere on the board
!SHUT_DOWN: A27.F2; also elsewhere on the board
!STROBE: C17.T2 (T); also elsewhere on the board
+3V(13): C25.A1, D16.D1 (S), D17.V1, D25.A1; also elsewhere on the board
+5V(1): A28.F2
+5V(2): A28.H2
+5V(3): A28.J2
+5V(4): A28.K2
+5V(5): A28.L2
+5V(6): A28.M2
A01B2: A01.B2, A28.B2
A01_10V: A01.V1, A28.N2
A25F2: A25.F2, C25.U2, D25.U2
A26F2: A26.F2, C25.L2, D25.L2
B01_10V: A28.P2, B01.V1
B22S2: B22.S2, B27.R2
B22T2: B22.T2, B27.S2
B25F2: B25.F2, C25.E1, D25.E1
B26F2: B26.F2, C25.M1, D25.M1
B27K2: B27.J2, B27.K2, B28.J2, B28.K2
B29B2: B28.B2; also elsewhere on the board
B36S2: B27.F2, B36.S2
B36T2: A28.E1, B36.T2
B36V2: A27.T2, A28.U2, B36.V2
B_INHIBIT: D17.J2 (OUT); also elsewhere on the board
B_MEM_ENABLE: C25.E2, C25.N2, D17.E1 (OUT), D17.L1 (OUT), D25.E2, D25.N2; also elsewhere on the board
C01_10V: A28.R2, C01.V1
C13V2: C13.V2 (OUT), C15.A1 (IN1)
C15C1: C15.C1 (OUT), D14.H2
C15F2: C15.F2 (OUT), D16.N2 (S)
C15K1: C15.K1 (OUT), D16.R1 (S)
C15K2: C15.B1 (IN2), C15.K2 (OUT), D16.F2 (S)
CYCLE: C15.E2 (IN2), D16.H2 (1)
CYC_DONE: C15.J2 (IN2), C15.M1 (IN2), D15.F1 (OUT), D16.H1 (C), D16.L2 (C), D16.N1 (C)
D01_10V: A28.S2, D01.V1
D14F1: C15.D2 (IN1), D14.F1 (OUT)
D14J1: C15.J1 (IN2), D14.J1 (OUT), D15.H2, D17.M1 (IN1), D17.N1 (IN2)
D14M2: D14.E1 (IN), D14.M2
D14N2: D14.H1 (IN), D14.N2
D15J1: C17.P2, D15.J1 (OUT), D16.D2 (C)
D15L2: D15.H1 (IN), D15.L2
D15T2: D15.E1 (IN), D15.T2
GND: A25.E2, A28.C2, A28.D2, A28.E2, B26.E2, B28.C2, B28.D2, B28.E2, B28.F2, B28.H2, B34.A1 (GND), B34.C1 (GND), B34.C2 (GND), B34.F1 (GND), B34.F2 (GND), B34.J2 (GND), B34.K1 (GND), B34.L2 (GND), B34.N1 (GND), B34.N2 (GND), B34.R1 (GND), B34.R2 (GND), B34.T1 (GND), B34.U2 (GND), B36.A1 (GND), B36.C1 (GND), B36.C2 (GND), B36.F1 (GND), B36.F2 (GND), B36.J2 (GND), B36.K1 (GND), B36.L2 (GND), B36.N1 (GND), B36.N2 (GND), B36.R1 (GND), B36.R2 (GND), B36.T1 (GND), B36.U2 (GND), C13.C2 (GND), C13.T1 (GND), C15.C2 (GND), C15.T1 (GND), C17.C2 (GND), C25.C2 (GND), C25.T1 (GND), C26.C2 (GND), D13.C2 (GND), D13.T1 (GND), D14.C2 (GND), D14.T1 (GND), D15.C2 (GND), D15.T1 (GND), D16.C2 (GND), D16.E2 (D), D16.J1 (D), D16.M2 (D), D16.P1 (D), D16.T1 (GND), D16.T2 (D), D17.C2 (GND), D17.T1 (GND), D25.C2 (GND), D25.T1 (GND); also elsewhere on the board
INHIBIT: C15.H1 (IN1), D16.P2 (1)
LOCK: C15.H2 (IN1), D16.V2 (1)
MEM_DONE: C17.U2 (IN), D13.P1 (OUT)
MEM_DONE_NOT: C15.N1 (OUT), D13.N1 (IN)
MEM_RET: A25.B2, A26.B2, B25.B2, B26.B2, B28.L2
MEM_START: C13.U2 (IN4), D16.B1 (C); also elsewhere on the board
MEM_SUPPLY+: A25.J2, A25.U2, A26.E2, A26.J2, A26.U2, B25.E2, B26.H2, B27.M2, B28.M2, B28.N2, B28.P2, B28.R2; also elsewhere on the board
MEM_SUPPLY-: A25.H2, A26.H2, A26.M2, B25.H2, B25.J2, B25.U2, B26.J2, B26.U2, B27.V2, B28.S2, B28.T2, B28.U2, B28.V2; also elsewhere on the board
NEG_CLAMP: A26.R2, C25.V2, D25.V2; also elsewhere on the board
PANEL_LOCK: A28.T2, B01.N2
READ: C17.R2 (R), C25.D2, C25.M2, D16.L1 (1), D25.D1, D25.L1
SLICE: A28.V2; also elsewhere on the board
STOP_OK: A27.H2; also elsewhere on the board
STROBE_FIELD0: C17.S2 (S); also elsewhere on the board
VCC: A28.A2, B28.A2, C13.A2 (VCC), C15.A2 (VCC), C17.A2 (VCC), C25.A2 (VCC), C26.A2 (VCC), D13.A2 (VCC), D14.A2 (VCC), D15.A2 (VCC), D16.A2 (VCC), D17.A2 (VCC), D25.A2 (VCC); also elsewhere on the board
WRITE: C25.D1, C25.L1, D16.S1 (1), D16.S2 (C), D25.D2, D25.M2
X_R/W_RETURN: B26.D2, D25.F2, D25.K1; also elsewhere on the board
X_R/W_SOURCE: A26.D2, C25.F2, C25.K1; also elsewhere on the board
Y_R/W_RETURN: A25.D2, D25.P2, D25.S1; also elsewhere on the board
Y_R/W_SOURCE: B25.D2, C25.P2, C25.S1; also elsewhere on the board

Notes on the sheet:
Thermistor
G826
AB27
Regulator and Power Detector
G785
AB28
Lamp Power
Power Supply
Connector and
Regulator
D-BS-8L-0-13
Memory Control

Schematic: pdp8l.sch, sheet 16

Parts:
A17, A18, A19, A20: G020; H807
A21, A22: W025A; H807
A23, A24: G228; H807
A25, A26: G624; H807
B18, B19, B20: G020; H807
B21, B22: W025B; H807
B23, B24: G228; H807
B25, B26: G624; H807
B35: M903; H807

Connections:
!MB00: A23.D2; also elsewhere on the board
!MB01: A23.D1; also elsewhere on the board
!MB02: A23.M2; also elsewhere on the board
!MB03: A23.L1; also elsewhere on the board
!MB04: B23.D2; also elsewhere on the board
!MB05: B23.D1; also elsewhere on the board
!MB06: B23.M2; also elsewhere on the board
!MB07: B23.L1; also elsewhere on the board
!MB08: B24.D2; also elsewhere on the board
!MB09: B24.D1; also elsewhere on the board
!MB10: B24.M2; also elsewhere on the board
!MB11: B24.L1; also elsewhere on the board
!MEM_BEGIN: A17.B1, A18.B1, A19.B1, A20.B1, B18.B1, B19.B1, B20.B1; also elsewhere on the board
-15V: A17.B2 (-15V), A18.B2 (-15V), A19.B2 (-15V), A20.B2 (-15V), B18.B2 (-15V), B19.B2 (-15V), B20.B2 (-15V); also elsewhere on the board
A21C2: A18.D2, A21.C2
A21D2: A18.E2, A21.D2
A21E2: A18.L1, A21.E2
A21F2: A18.M1, A21.F2
A21H2: A19.D2, A21.H2
A21J2: A19.E2, A21.J2
A21K2: A19.L1, A21.K2
A21L2: A19.M1, A21.L2
A21M2: A20.D2, A21.M2
A21N2: A20.E2, A21.N2
A21P2: A20.L1, A21.P2
A21R2: A20.M1, A21.R2
A21S2: A17.D2, A21.S2
A21T2: A17.E2, A21.T2
A23E1: A23.E1, A25.M2
A23F2: A23.F2, A25.N2
A23H1: A22.E2, A23.H1 (J)
A23J1: A22.F2, A23.J1 (K)
A23J2: A22.C2, A23.J2 (J)
A23K2: A22.D2, A23.K2 (K)
A23M1: A23.M1, A25.K2
A23P1: A22.K2, A23.P1 (J)
A23P2: A23.P2, A25.L2
A23R1: A22.L2, A23.R1 (K)
A23S2: A22.H2, A23.S2 (J)
A23T2: A22.J2, A23.T2 (K)
A24F2: A24.F2, A26.N2
A24J2: A22.S2, A24.J2 (J)
A24K2: A22.T2, A24.K2 (K)
A25P2: A23.H2 (H), A25.P2
A25R2: A23.F1 (H), A25.R2
A25S2: A23.R2 (H), A25.S2
A25T2: A23.N1 (H), A25.T2
A26P2: A24.H2 (H), A26.P2
B21C2: B18.D2, B21.C2
B21D2: B18.E2, B21.D2
B21E2: B18.L1, B21.E2
B21F2: B18.M1, B21.F2
B21H2: B19.D2, B21.H2
B21J2: B19.E2, B21.J2
B21K2: B19.L1, B21.K2
B21L2: B19.M1, B21.L2
B21M2: B20.D2, B21.M2
B21N2: B20.E2, B21.N2
B21P2: B20.L1, B21.P2
B21R2: B20.M1, B21.R2
B23E1: B23.E1, B25.M2
B23F2: B23.F2, B25.N2
B23H1: A22.P2, B23.H1 (J)
B23J1: A22.R2, B23.J1 (K)
B23J2: A22.M2, B23.J2 (J)
B23K2: A22.N2, B23.K2 (K)
B23M1: B23.M1, B25.K2
B23P1: B22.E2, B23.P1 (J)
B23P2: B23.P2, B25.L2
B23R1: B22.F2, B23.R1 (K)
B23S2: B22.C2, B23.S2 (J)
B23T2: B22.D2, B23.T2 (K)
B24E1: B24.E1, B26.M2
B24F2: B24.F2, B26.N2
B24H1: B22.K2, B24.H1 (J)
B24J1: B22.L2, B24.J1 (K)
B24J2: B22.H2, B24.J2 (J)
B24K2: B22.J2, B24.K2 (K)
B24M1: B24.M1, B26.K2
B24P1: B22.P2, B24.P1 (J)
B24P2: B24.P2, B26.L2
B24R1: B22.R2, B24.R1 (K)
B24S2: B22.M2, B24.S2 (J)
B24T2: B22.N2, B24.T2 (K)
B25P2: B23.H2 (H), B25.P2
B25R2: B23.F1 (H), B25.R2
B25S2: B23.R2 (H), B25.S2
B25T2: B23.N1 (H), B25.T2
B26P2: B24.H2 (H), B26.P2
B26R2: B24.F1 (H), B26.R2
B26S2: B24.R2 (H), B26.S2
B26T2: B24.N1 (H), B26.T2
B_INHIBIT: A23.A1, A24.A1, B23.A1, B24.A1; also elsewhere on the board
B_MEM_ENABLE: A17.T2, A18.T2, A19.T2, A20.T2, A23.E2, A23.N2, A24.E2, B18.T2, B19.T2, B20.T2, B23.E2, B23.N2, B24.E2, B24.N2; also elsewhere on the board
GND: A17.C2 (GND), A17.L1, A17.M1, A17.T1 (GND), A18.C2 (GND), A18.T1 (GND), A19.C2 (GND), A19.T1 (GND), A20.C2 (GND), A20.T1 (GND), A23.C2 (GND), A23.T1 (GND), A24.C2 (GND), A24.D1, A24.L1, A24.M2, A24.N2, A24.T1 (GND), B18.C2 (GND), B18.T1 (GND), B19.C2 (GND), B19.T1 (GND), B20.C2 (GND), B20.T1 (GND), B23.C2 (GND), B23.T1 (GND), B24.C2 (GND), B24.T1 (GND), B35.A1 (GND), B35.C1 (GND), B35.C2 (GND), B35.F1 (GND), B35.F2 (GND), B35.J2 (GND), B35.K1 (GND), B35.L2 (GND), B35.N1 (GND), B35.N2 (GND), B35.R1 (GND), B35.R2 (GND), B35.T1 (GND), B35.U2 (GND); also elsewhere on the board
MB_PARITY_ODD: A24.D2; also elsewhere on the board
MEM00: A18.A1, B35.D1; also elsewhere on the board
MEM01: A18.U2, B35.E1; also elsewhere on the board
MEM02: A19.A1, B35.H1; also elsewhere on the board
MEM03: A19.U2, B35.J1; also elsewhere on the board
MEM04: A20.A1, B35.L1; also elsewhere on the board
MEM05: A20.U2, B35.M1; also elsewhere on the board
MEM06: B18.A1, B35.P1; also elsewhere on the board
MEM07: B18.U2, B35.S1; also elsewhere on the board
MEM08: B19.A1, B35.D2; also elsewhere on the board
MEM09: B19.U2, B35.E2; also elsewhere on the board
MEM10: B20.A1, B35.H2; also elsewhere on the board
MEM11: B20.U2, B35.K2; also elsewhere on the board
MEM_P: A17.A1, B35.B1; also elsewhere on the board
MEM_SUPPLY+: A23.K1, A23.L2, A23.S1, A23.U2, A24.L2, B23.K1, B23.L2, B23.S1, B23.U2, B24.K1, B24.L2, B24.S1, B24.U2; also elsewhere on the board
MEM_SUPPLY-: A23.V2, A24.V2, B23.V2, B24.V2; also elsewhere on the board
SLICE: A17.S2, A18.S2, A19.S2, A20.S2, B18.S2, B19.S2, B20.S2; also elsewhere on the board
STROBE_FIELD0: A17.D1, A17.R1, A18.D1, A18.R1, A19.D1, A19.R1, A20.D1, A20.R1, B18.D1, B18.R1, B19.D1, B19.R1, B20.D1, B20.R1; also elsewhere on the board
VCC: A17.A2 (VCC), A18.A2 (VCC), A19.A2 (VCC), A20.A2 (VCC), A23.A2 (VCC), A24.A2 (VCC), B18.A2 (VCC), B19.A2 (VCC), B20.A2 (VCC), B23.A2 (VCC), B24.A2 (VCC); also elsewhere on the board

Notes on the sheet:
Sense P
Sense 00
Sense 01
Sense 02
Sense 03
Sense 04
Sense 05
Sense 06
Sense 07
Sense 08
Sense 09
Sense 10
Sense 11
* Used with MP8L
D-BS-8L-0-14
Sense Amps and Inhibit Drivers

Schematic: pdp8l.sch, sheet 17

Parts:
C21: H807
C22: G610A; H807
C23, C24: G221; H807
D18, D19: G221; H807
D20: G611B; H807
D21: H807

Connections:
!MA00: C24.E2; also elsewhere on the board
!MA03: D18.E2; also elsewhere on the board
B_MEM_ENABLE: C23.D2, C24.D2, D18.D2, D19.D2; also elsewhere on the board
C23J2: C22.N2, C23.J2
C23K2: C22.M2, C23.K2
C23L2: C22.R2, C23.L2
C23M2: C22.P2, C23.M2
C23N2: C22.T2, C23.N2
C23P2: C22.S2, C23.P2
C23R2: C22.V2, C23.R2
C23S2: C22.U2, C23.S2
C24J2: C22.D2, C24.J2
C24K2: C22.C2, C24.K2
C24M2: C22.E2, C24.M2
C24N2: C22.J2, C24.N2
C24P2: C22.H2, C24.P2
C24R2: C22.L2, C24.R2
C24S2: C22.K2, C24.S2
D18J2: D18.J2, D20.K2
D18K2: D18.K2, D20.L2
D18L2: D18.L2, D20.H2
D18M2: D18.M2, D20.J2
D18N2: D18.N2, D20.E2
D18P2: D18.P2, D20.F2
D18R2: D18.R2, D20.C2
D18S2: D18.S2, D20.D2
D19J2: D19.J2, D20.U2
D19K2: D19.K2, D20.V2
D19L2: D19.L2, D20.S2
D19M2: D19.M2, D20.T2
D19N2: D19.N2, D20.P2
D19P2: D19.P2, D20.R2
D19R2: D19.R2, D20.M2
D19S2: D19.S2, D20.N2
GND: C23.C2 (GND), C24.C2 (GND), D18.C2 (GND), D19.C2 (GND); also elsewhere on the board
MA00: C23.E2; also elsewhere on the board
MA01: C23.H2, C24.H2; also elsewhere on the board
MA02: C23.F2, C24.F2; also elsewhere on the board
MA03: D19.E2; also elsewhere on the board
MA04: D18.H2, D19.H2; also elsewhere on the board
MA05: D18.F2, D19.F2; also elsewhere on the board
NEG_CLAMP: C23.V2, C24.V2, D18.V2, D19.V2; also elsewhere on the board
V24L2: C22.F2, C24.L2
VCC: C23.A2 (VCC), C24.A2 (VCC), D18.A2 (VCC), D19.A2 (VCC); also elsewhere on the board
X_R/W_RETURN: D18.T2, D19.T2; also elsewhere on the board
X_R/W_SOURCE: C23.T2, C24.T2; also elsewhere on the board

Notes on the sheet:
Core Memory:
G611
CD22
G610
CD20
* G611 in CD22 is replaced with G612 for MP8L.
D-BS-8L-0-15
X-Axis Selection

Schematic: pdp8l.sch, sheet 18

Parts:
C18, C19: G221; H807
C20: G610A; H807
D22: G611B; H807
D23, D24: G221; H807

Connections:
!MA06: C19.E2; also elsewhere on the board
!MA09: D23.E2; also elsewhere on the board
B_MEM_ENABLE: C18.D2, C19.D2, D23.D2, D24.D2; also elsewhere on the board
C18J2: C18.J2, C20.N2
C18K2: C18.K2, C20.M2
C18L2: C18.L2, C20.R2
C18M2: C18.M2, C20.P2
C18N2: C18.N2, C20.T2
C18P2: C18.P2, C20.S2
C18R2: C18.R2, C20.V2
C18S2: C18.S2, C20.U2
C19J2: C19.J2, C20.D2
C19K2: C19.K2, C20.C2
C19L2: C19.L2, C20.F2
C19M2: C19.M2, C20.E2
C19N2: C19.N2, C20.J2
C19P2: C19.P2, C20.H2
C19R2: C19.R2, C20.L2
C19S2: C19.S2, C20.K2
D23J2: D22.K2, D23.J2
D23K2: D22.L2, D23.K2
D23L2: D22.H2, D23.L2
D23M2: D22.J2, D23.M2
D23N2: D22.E2, D23.N2
D23P2: D22.F2, D23.P2
D23R2: D22.C2, D23.R2
D23S2: D22.D2, D23.S2
D24J2: D22.U2, D24.J2
D24K2: D22.V2, D24.K2
D24L2: D22.S2, D24.L2
D24M2: D22.T2, D24.M2
D24N2: D22.P2, D24.N2
D24P2: D22.R2, D24.P2
D24R2: D22.M2, D24.R2
D24S2: D22.N2, D24.S2
GND: C18.C2 (GND), C19.C2 (GND), D23.C2 (GND), D24.C2 (GND); also elsewhere on the board
MA06: C18.E2; also elsewhere on the board
MA07: C18.H2, C19.H2; also elsewhere on the board
MA08: C18.F2, C19.F2; also elsewhere on the board
MA09: D24.E2; also elsewhere on the board
MA10: D23.H2, D24.H2; also elsewhere on the board
MA11: D23.F2, D24.F2; also elsewhere on the board
NEG_CLAMP: C18.V2, C19.V2, D23.V2, D24.V2; also elsewhere on the board
VCC: C18.A2 (VCC), C19.A2 (VCC), D23.A2 (VCC), D24.A2 (VCC); also elsewhere on the board
Y_R/W_RETURN: D23.T2, D24.T2; also elsewhere on the board
Y_R/W_SOURCE: C18.T2, C19.T2; also elsewhere on the board

Notes on the sheet:
Y-Axis Selection
G611
CD22
G610
CD20
* G611 in CD22 is replaced with G612 for MP8L.
D-BS-8L-0-16

Schematic: pdp8l.sch, sheet 19

Parts:
A01: G921; H807
A35: M111; H807
B01: G921; H807
B34, B36: M903; H807
C01: G921; H807
C05, C15: M113; H807
C26: M002; H807
D01: G921; H807
D12: M113; H807
D17: M617; H807
D26: H807

Connections:
!E_SET: D17.T2 (IN3), D17.U2 (IN4); also elsewhere on the board
!F_SET: D17.R2 (IN1), D17.S2 (IN2); also elsewhere on the board
!IR0: C15.R1 (IN2); also elsewhere on the board
!JMP: C15.R2 (IN2); also elsewhere on the board
!JMS: C15.P2 (IN1); also elsewhere on the board
!KEY_LA: C05.U2 (IN2); also elsewhere on the board
!MA00: A35.J1 (IN); also elsewhere on the board
!MA01: A35.L1 (IN); also elsewhere on the board
!MA02: A35.N1 (IN); also elsewhere on the board
!MA03: A35.R1 (IN); also elsewhere on the board
!MA04: A35.V1 (IN); also elsewhere on the board
!MA05: A35.E2 (IN); also elsewhere on the board
!MA06: A35.H2 (IN); also elsewhere on the board
!MA07: A35.K2 (IN); also elsewhere on the board
!MA08: A35.M2 (IN); also elsewhere on the board
!MA09: A35.P2 (IN); also elsewhere on the board
!MA10: A35.S2 (IN); also elsewhere on the board
!MA11: A35.U2 (IN); also elsewhere on the board
!RESTART: C05.T2 (IN1), C26.U2; also elsewhere on the board
!WC_SET: C26.T2, D12.T2 (IN1); also elsewhere on the board
!WORD_COUNT: D12.U2 (IN2); also elsewhere on the board
B36B1: B36.B1, C15.S1 (OUT)
B36D1: A35.B1 (OUT), B36.D1
B36D2: B36.D2, D17.V2 (OUT)
B36E1: A35.D2 (OUT), B36.E1
B36E2: B36.E2, C15.S2 (OUT)
B36H2: B36.H2, D17.P2 (OUT)
B36J1: B36.J1, C15.V2 (OUT)
B36M1: B36.M1, C15.N2 (OUT)
B36P1: A01.C1, B36.P1
B36S1: A01.B1, B36.S1
B_SET: A35.C1 (IN); also elsewhere on the board
C05V2: C05.V2 (OUT), C15.T2 (IN1)
D12V2: A35.A1 (IN), D12.V2 (OUT)
DEFER: C15.P1 (IN1); also elsewhere on the board
GND: A01.C2, A01.T1, A35.C2 (GND), A35.T1 (GND), B01.C2, B01.T1, B34.A1 (GND), B34.C1 (GND), B34.C2 (GND), B34.F1 (GND), B34.F2 (GND), B34.J2 (GND), B34.K1 (GND), B34.L2 (GND), B34.N1 (GND), B34.N2 (GND), B34.R1 (GND), B34.R2 (GND), B34.T1 (GND), B34.U2 (GND), B36.A1 (GND), B36.C1 (GND), B36.C2 (GND), B36.F1 (GND), B36.F2 (GND), B36.J2 (GND), B36.K1 (GND), B36.L2 (GND), B36.N1 (GND), B36.N2 (GND), B36.R1 (GND), B36.R2 (GND), B36.T1 (GND), B36.U2 (GND), C01.C2, C01.T1, C05.C2 (GND), C05.T1 (GND), C15.C2 (GND), C15.T1 (GND), C26.C2 (GND), D01.C2, D01.T1, D12.C2 (GND), D12.T1 (GND), D17.C2 (GND), D17.T1 (GND); also elsewhere on the board
INT_OK: C15.L2 (IN1); also elsewhere on the board
KEY_LA: D17.M2 (IN3), D17.N2 (IN4); also elsewhere on the board
MFTP0: C15.U2 (IN2); also elsewhere on the board
MFTP1: D17.K2 (IN1), D17.L2 (IN2); also elsewhere on the board
MMA00: A35.K1 (OUT), B34.D1
MMA01: A35.M1 (OUT), B34.E1
MMA02: A35.P1 (OUT), B34.H1
MMA03: A35.S1 (OUT), B34.J1
MMA04: A35.U1 (OUT), B34.L1
MMA05: A35.F2 (OUT), B34.M1
MMA06: A35.J2 (OUT), B34.P1
MMA07: A35.L2 (OUT), B34.S1
MMA08: A35.N2 (OUT), B34.D2
MMA09: A35.R2 (OUT), B34.E2
MMA10: A35.T2 (OUT), B34.H2
MMA11: A35.V2 (OUT), B34.K2
TS4: C15.M2 (IN2); also elsewhere on the board
VCC: A01.A2, A35.A2 (VCC), B01.A2, C01.A2, C05.A2 (VCC), C15.A2 (VCC), C26.A2 (VCC), D01.A2, D12.A2 (VCC), D17.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-8L-0-17
Misc. Connections
Empty:

Schematic: pdp8l.sch, sheet 20

Parts:
A36: M703; H807
C26: M002; H807

Connections:
!MB03: A36.D2; also elsewhere on the board
!MB04: A36.E2; also elsewhere on the board
!MB06: A36.H2; also elsewhere on the board
!MB07: A36.J2; also elsewhere on the board
!MB08: A36.K2; also elsewhere on the board
!PWR_LOW: A36.R2, C26.S2; also elsewhere on the board
!PWR_SKP: A36.L2; also elsewhere on the board
!RESTART: A36.U1; also elsewhere on the board
!SHUT_DOWN: A36.U2; also elsewhere on the board
GND: A36.C2, A36.T1, C26.C2 (GND); also elsewhere on the board
IOP2: A36.M2; also elsewhere on the board
MB05: A36.F2; also elsewhere on the board
STOP_OK: A36.P2; also elsewhere on the board
VCC: A36.A2, C26.A2 (VCC); also elsewhere on the board

Notes on the sheet:
D-BS-KP8L-0-1
Power Failure
M703
A36

Schematic: pdp8l.sch, sheet 21

Parts:
AB31: M710; H807-2
C34: M916; H807

Connections:
!INITIALIZE: AB31.AS2; also elsewhere on the board
!MB03: AB31.BF2; also elsewhere on the board
!MB04: AB31.BD1; also elsewhere on the board
!MB05: AB31.BD2; also elsewhere on the board
!MB06: AB31.BE1; also elsewhere on the board
!MB08: AB31.BF1; also elsewhere on the board
!RDR_DONE: AB31.BH2, C34.M1
!RDR_INT: AB31.BS2; also elsewhere on the board
!RDR_SKP: AB31.BN2; also elsewhere on the board
AC04: AB31.AH1; also elsewhere on the board
AC05: AB31.AH2; also elsewhere on the board
AC06: AB31.AF1; also elsewhere on the board
AC07: AB31.AF2; also elsewhere on the board
AC08: AB31.AE1; also elsewhere on the board
AC09: AB31.AE2; also elsewhere on the board
AC10: AB31.AD1; also elsewhere on the board
AC11: AB31.AD2; also elsewhere on the board
B31U2: AB31.BU2, C34.U1
B31V1: AB31.AU1, AB31.BV1
C34D1: AB31.AV2, C34.D1
C34E1: AB31.AT2, C34.E1
GND: AB31.AC2 (GND), AB31.AT1 (GND), AB31.BC2 (GND), AB31.BT1 (GND), C34.C1, C34.T1; also elsewhere on the board
IOP1: AB31.AR2; also elsewhere on the board
IOP2: AB31.AR1; also elsewhere on the board
IOP4: AB31.AP2; also elsewhere on the board
MB07: AB31.BE2; also elsewhere on the board
PB0: AB31.AK1, C34.H1
PB1: AB31.AL1, C34.J1
PB2: AB31.AM1, C34.K1
PB3: AB31.AN1, C34.L1
PB4: AB31.AK2, C34.N1
PB5: AB31.AL2, C34.P1
PB6: AB31.AM2, C34.R1
PB7: AB31.AN2, C34.S1
VCC: AB31.AA2 (VCC), AB31.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
Punch Control

Schematic: pdp8l.sch, sheet 22

Parts:
AB29: M715; H807-2
AB30: M705; H807-2
C34: M916; H807

Connections:
!A: AB30.BP2, C34.R2
!B: AB30.BR1, C34.S2
!ENABLE: AB29.AK2 (AK), AB30.BK2
!HSR_RUN: AB29.BS2 (BS), AB30.AK1
!INITIALIZE: AB30.BP1; also elsewhere on the board
!INT_IO_BUS4: AB30.AP2; also elsewhere on the board
!INT_IO_BUS5: AB30.AS2; also elsewhere on the board
!INT_IO_BUS6: AB30.AR1; also elsewhere on the board
!INT_IO_BUS7: AB30.AN2; also elsewhere on the board
!INT_IO_BUS8: AB30.AS1; also elsewhere on the board
!INT_IO_BUS9: AB30.AP1; also elsewhere on the board
!INT_IO_BUS10: AB30.AR2; also elsewhere on the board
!INT_IO_BUS11: AB30.AN1; also elsewhere on the board
!MB03: AB30.BD2; also elsewhere on the board
!MB04: AB30.BE2; also elsewhere on the board
!MB05: AB30.BE1; also elsewhere on the board
!MB06: AB30.BF2; also elsewhere on the board
!MB07: AB30.BF1; also elsewhere on the board
!RDR_INT: AB30.AL2; also elsewhere on the board
!RDR_SKP: AB30.AK2; also elsewhere on the board
!SHIFT: AB29.AT2 (AT), AB30.BD1
-15V: C34.B2; also elsewhere on the board
A: AB30.BS1, C34.P2
B: AB30.BU2, C34.T2
B29B2: AB29.BB2 (-15V); also elsewhere on the board
CLOCK1: AB29.AU2 (AU), AB30.BS2
FEED_HOLE: AB30.BM2, C34.N2
GND: AB29.AC2 (GND), AB29.BC2 (GND), AB30.AC2 (GND), AB30.AT1 (GND), AB30.BC2 (GND), AB30.BT1 (GND); also elsewhere on the board
IOP1: AB30.AU2; also elsewhere on the board
IOP2: AB30.AV2; also elsewhere on the board
IOP4: AB30.BK1; also elsewhere on the board
MB08: AB30.BH2; also elsewhere on the board
PWR: AB30.BR2, C34.U2
RDR_FEED_SW: AB29.BP2 (BP), AB30.BM1, C34.V2
RD_HOLE1: AB30.AD2, C34.D2
RD_HOLE2: AB30.AD1, C34.E2
RD_HOLE3: AB30.AE2, C34.F2
RD_HOLE4: AB30.AE1, C34.H2
RD_HOLE5: AB30.AH2, C34.J2
RD_HOLE6: AB30.AH1, C34.K2
RD_HOLE7: AB30.AF2, C34.L2
RD_HOLE8: AB30.AF1, C34.M2
SHIFT: AB29.AS2 (AS), AB30.BJ1
STOP_COMPLETE: AB29.BR2 (BR), AB30.BN2
VCC: AB29.AA2 (VCC), AB29.BA2 (VCC), AB30.AA2 (VCC), AB30.BA2 (VCC); also elsewhere on the board

Notes on the sheet:
Reader Control
